options:
  parameters:
    author: thompa
    generate_options: qt_gui
    id: modem_test
    output_language: python
    title: Modem under test
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '120000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: gen-ax1200.c32
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: gen-ax1200-200ksps.c32
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: modem_ax1200_0
  id: modem_ax1200
  parameters:
    audio_rate: '12000'
    baud: '1200'
    samp_rate: samp_rate
  states: {}
- name: modem_fsk_0
  id: modem_fsk
  parameters:
    baud: baud
    samp_rate: '200000'
  states: {state: disabled}
- name: modem_qpsk_0
  id: modem_qpsk
  parameters:
    baud: baud
    samp_rate: samp_rate
  states: {state: disabled}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '53001'
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '53002'
    type: UDP_CLIENT
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Transmitted air"'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: air
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: air
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [modem_ax1200_0, '0', blocks_multiply_const_vxx_0, '0']
- [modem_ax1200_0, pduout, blocks_message_debug_0, print]
- [modem_ax1200_0, pduout, network_socket_pdu_1, pdus]
- [modem_fsk_0, '0', blocks_multiply_const_vxx_0, '0']
- [modem_fsk_0, outpdu, blocks_message_debug_0, print]
- [modem_fsk_0, outpdu, network_socket_pdu_1, pdus]
- [modem_qpsk_0, '0', blocks_multiply_const_vxx_0, '0']
- [modem_qpsk_0, pduout, blocks_message_debug_0, print]
- [modem_qpsk_0, pduout, network_socket_pdu_1, pdus]
- [network_socket_pdu_0, pdus, modem_ax1200_0, pduin]
- [network_socket_pdu_0, pdus, modem_fsk_0, inpdu]
- [network_socket_pdu_0, pdus, modem_qpsk_0, pduin]
- [virtual_source_0, '0', modem_ax1200_0, '0']
- [virtual_source_0, '0', modem_fsk_0, '0']
- [virtual_source_0, '0', modem_qpsk_0, '0']

metadata:
  file_format: 1

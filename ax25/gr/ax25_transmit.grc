options:
  parameters:
    author: Thomas Habets
    generate_options: qt_gui
    id: ax25_transmit
    output_language: python
    title: AX.25 transmit
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: bps
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '144775000'
  states: {}
- name: idle_buffer_len
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: monitor_volume
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '10'
    value: '0.1'
  states: {}
- name: offset
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: ogain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: tag_packet_idle
  id: variable_tag_object
  parameters:
    key: pmt.intern("packet_len")
    offset: '0'
    src: pmt.intern("src")
    value: pmt.to_pmt(idle_buffer_len)
  states: {}
- name: tag_tx_off
  id: variable_tag_object
  parameters:
    key: pmt.intern("tx")
    offset: '0'
    src: pmt.intern("src")
    value: pmt.to_pmt(0)
  states: {}
- name: tag_tx_on
  id: variable_tag_object
  parameters:
    key: pmt.intern("tx")
    offset: '0'
    src: pmt.intern("src")
    value: pmt.to_pmt(1)
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: 5e3
    quad_rate: audio_rate*2
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: audio_rate*2
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {state: disabled}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1200'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: generated-50ksps.raw
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_by_tag_value_cc_0
  id: blocks_multiply_by_tag_value_cc
  parameters:
    tagname: tx
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1000'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: monitor_volume
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: audio_rate//bps
    type: float
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_tag_share_0
  id: blocks_tag_share
  parameters:
    io_type: byte
    share_type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: audio_rate
    sensitivity: 2*math.pi
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[tag_tx_on]'
    type: byte
    vector: '[0]'
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[tag_tx_off, tag_packet_idle]'
    type: byte
    vector: '[0]*idle_buffer_len'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio.gr import pmt

      def stuff(bits):
          stuffed = []
          n = 0
          for bit in bits:
              if bit:
                  n += 1
                  if n == 6:
                      n = 1
                      stuffed.append(0)
              else:
                  n = 0
              stuffed.append(bit)
          return stuffed
          
      def scramble(bits):
          scrambled = []
          for n, bit in enumerate(bits):
              if n == 0:
                  scrambled.append(bit)
                  continue
              scrambled.append(1 ^ bit ^ scrambled[n-1])
          return scrambled

      def invert(bits):
          return [(x ^ 1) for x in bits]

      def unpack(byts):
          bits = []
          for byt in byts:
              for b in [1,2,4,8,16,32,64,128]:
                  bits.append(0 + (not not (byt & b)))
          return bits

      def encode(byts):
          bits = unpack(byts)

          head = ([0] + [1]*6 + [0]) * 24
          tail = ([0] + [1]*6 + [0]) * 2
          bits = head+stuff(bits)+tail
          # correct so far

          # Scramble
          bits = scramble(bits)
          print(bits)
          return bits

      if False:
          print(encode([1]))
          assert encode([1]) == [0,0,1,1,1,1,1,0,1]
          print(encode([2]))
          assert encode([2]) == [1,0,0,1,1,1,1,1]

          print(encode([0xf0]))
          assert encode([0xf0]) == [1,1,1,1,0,1,1,1]
          print(encode([0xff]))
          assert encode([0xff]) == [0,1,1,1,1,1,0,1,1]

          print(encode([0x55]))
          assert encode([0x55]) == [0,0,0,0,0,0,0,0]

          print(encode([0xAA]))
          assert encode([0xAA]) == [1,0,0,0,0,0,0,0]

          print(encode([
              1,
              2,
              0xf0,
              0xff,
              0,
              0x55,
              0xaa,
          ]))

          assert encode([
              1,
              2,
              0xf0,
              0xff,
              0,
              0x55,
              0xAA,
          ]) == [
              1,1,0,0,0,0,0,0,   # 1
              0,1,1,0,0,0,0,0,   # 2
              0,0,0,0,1,0,0,0,   # 0xf0
              0,0,0,0,0,0,0,0,   # 0xff with prev bit
              1,0,0,0,0,0,0,0,   # 0 with prev bit
              1,1,1,1,1,0,1,1,1, # 0x55
              0,1,1,1,1,1,0,1,1, # 0xAA with prev bit
          ]

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='AX.25 bit encoding',
                  in_sig=[],
                  out_sig=[]
              )
              
              self._in = pmt.intern("in")
              self._out = pmt.intern("out")
              self.message_port_register_in(self._in)
              self.message_port_register_out(self._out)
              self.set_msg_handler(self._in, self._handle)

          def _handle(self, pdu):
              byts = pmt.to_python(pmt.cdr(pdu))
              print("AX.25 bytes: %d" % len(byts))
              bits = encode(byts)
              print("AX.25: Publishing %d bits" % len(bits))
              v = pmt.init_u8vector(len(bits), bits)
              out = pmt.cons(pmt.PMT_NIL, v)
              self.message_port_pub(self._out, out)
              
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '-offset'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, offset-12500, offset+12500, 500)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Audio"'
    size: audio_rate
    srate: audio_rate
    tr_delay: '0.1'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"BBITS"'
    size: '128'
    srate: '1200'
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"Air"'
    size: samp_rate
    srate: samp_rate
    tr_delay: '0.1'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    name: '"Frequencies"'
    size: bps
    srate: bps
    tr_delay: '0.1'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '3000'
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate*2
    interp: samp_rate
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: '50000'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    taps: ''
    type: fff
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq-offset
    dev_args: '""'
    gain0: ogain
    len_tag_name: ''
    norm_gain0: 'True'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: bits
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: frequencies
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: audio
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: bits
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: frequencies
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: audio
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_3, '0']
- [analog_nbfm_tx_0, '0', analog_nbfm_rx_0, '0']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_3, '0']
- [blocks_complex_to_real_0, '0', virtual_sink_2, '0']
- [blocks_complex_to_real_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0_0, '0', virtual_sink_3, '0']
- [blocks_float_to_complex_0, '0', blocks_complex_to_real_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_multiply_by_tag_value_cc_0, '0']
- [blocks_multiply_by_tag_value_cc_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_2, '0', analog_nbfm_tx_0, '0']
- [blocks_multiply_const_vxx_3, '0', audio_sink_1, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_tag_share_0, '0']
- [blocks_repeat_0, '0', blocks_vco_f_0, '0']
- [blocks_socket_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_socket_pdu_0, pdus, epy_block_0, in]
- [blocks_tag_share_0, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_char_to_float_1, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_1, '0']
- [blocks_vco_f_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_tag_share_0, '1']
- [blocks_vector_source_x_1, '0', blocks_tagged_stream_mux_0, '1']
- [epy_block_0, out, blocks_message_debug_0, print_pdu]
- [epy_block_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_time_sink_x_2, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', uhd_usrp_sink_0, '0']
- [rational_resampler_xxx_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [rational_resampler_xxx_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', blocks_file_sink_0, '0']
- [virtual_source_1, '0', blocks_char_to_float_0, '0']
- [virtual_source_2, '0', blocks_repeat_0, '0']
- [virtual_source_3, '0', blocks_multiply_const_vxx_2, '0']

metadata:
  file_format: 1

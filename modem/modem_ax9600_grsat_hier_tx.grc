options:
  parameters:
    author: thomas@habets.se
    category: '[habets]'
    generate_options: hb
    id: modem_ax9600_grsat_hier_tx
    output_language: python
    title: 9600bps AX.25 transmitter
  states: {}

blocks:
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1/8.0
    lengthtagname: '''packet_len'''
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 10/8.0
    lengthtagname: '''packet_len'''
    type: complex
  states: {state: disabled}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: sps
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import time

      import numpy as np
      from gnuradio import gr
      from gnuradio.gr import pmt

      class blk(gr.basic_block):
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, tag="packet_len"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Length rewriter',
                  in_sig=[np.complex64],
                  out_sig=[]
              )
              self._buf = []
              self._tag = tag
              self._out = pmt.intern('out')
              self.message_port_register_out(self._out)

          def general_work(self, input_items, output_items):
              """example: multiply with constant"""
              
              tags = [x for x in self.get_tags_in_window(0,0,len(input_items[0]))
                      if self._tag == pmt.to_python(x.key)]
              print('Tags:',tags)
              src = 0
              for tag in tags:
                  print('src - dst', src, dst)
                  print('Consuming %d' % src)
                  self.consume(0, dst-src)
                  self._buf.extend(input_items[0][src:dst])
                  src = tag.offset - self.nitems_read(0)
                  if self._buf:
                      print("packet", self._buf)
                      self.message_port_pub(self._out, msg)
                      self._buf = []
              time.sleep(1)
              return 0
    tag: '''packet_len'''
  states: {state: disabled}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: message
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: 9600*sps
    interp: '25000'
    type: ccc
  states: {}
- name: satellites_hdlc_framer_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '7'
    preamble_bytes: '50'
  states: {}
- name: satellites_nrzi_encode_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: sps
  id: parameter
  parameters:
    type: intx
    value: '10'
  states: {}

connections:
- [blocks_pack_k_bits_bb_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_gmsk_mod_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [digital_gmsk_mod_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']
- [digital_gmsk_mod_0, '0', epy_block_0, '0']
- [digital_gmsk_mod_0, '0', rational_resampler_xxx_0, '0']
- [digital_scrambler_bb_0, '0', satellites_nrzi_encode_0, '0']
- [epy_block_0, out, pdu_pdu_to_tagged_stream_1, pdus]
- [pad_source_0, out, satellites_hdlc_framer_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', digital_scrambler_bb_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', pad_sink_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_null_sink_0, '0']
- [pdu_tagged_stream_to_pdu_0_0, pdus, blocks_message_debug_0, print]
- [rational_resampler_xxx_0, '0', pad_sink_0, '0']
- [satellites_hdlc_framer_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_nrzi_encode_0, '0', blocks_pack_k_bits_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0

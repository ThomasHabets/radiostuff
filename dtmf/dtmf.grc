options:
  parameters:
    author: thomas@habets.se
    generate_options: qt_gui
    id: dtmf
    output_language: python
    title: DTMF decoder
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: deci1
  id: variable
  parameters:
    value: '10'
  states: {}
- name: dtmfgain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '5'
  states: {}
- name: filter_length
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: freq_m
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '435'
  states: {}
- name: igain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sql_level
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '0'
    value: '-60'
  states: {}
- name: twidth
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(samp_rate/deci1)
    max_dev: 5e3
    quad_rate: int(samp_rate/deci1)
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sql_level
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {state: disabled}
- name: blocks_and_xx_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0_0_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0_0_0_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0_0_0_0_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0_1_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0_1_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0_1_0_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_1_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_1_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_1_0_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_1_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_1_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_1_0_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: dtmfgain
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.6'
    init: '0'
    low: '0.4'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.6'
    init: '0'
    low: '0.4'
  states: {}
- name: blocks_threshold_ff_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.6'
    init: '0'
    low: '0.4'
  states: {}
- name: blocks_threshold_ff_0_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.6'
    init: '0'
    low: '0.4'
  states: {}
- name: blocks_threshold_ff_0_0_1
  id: blocks_threshold_ff
  parameters:
    high: '0.6'
    init: '0'
    low: '0.4'
  states: {}
- name: blocks_threshold_ff_0_1
  id: blocks_threshold_ff
  parameters:
    high: '0.6'
    init: '0'
    low: '0.4'
  states: {}
- name: blocks_threshold_ff_0_1_0
  id: blocks_threshold_ff
  parameters:
    high: '0.6'
    init: '0'
    low: '0.4'
  states: {}
- name: blocks_threshold_ff_0_2
  id: blocks_threshold_ff
  parameters:
    high: '0.6'
    init: '0'
    low: '0.4'
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '0'
    decim: deci1
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,cutoff,twidth)
  states: {}
- name: goertzel_fc_0
  id: goertzel_fc
  parameters:
    freq: '1209'
    len: filter_length
    rate: audio_rate
  states: {}
- name: goertzel_fc_0_0
  id: goertzel_fc
  parameters:
    freq: '1336'
    len: filter_length
    rate: audio_rate
  states: {}
- name: goertzel_fc_0_0_0
  id: goertzel_fc
  parameters:
    freq: '1477'
    len: filter_length
    rate: audio_rate
  states: {}
- name: goertzel_fc_0_0_0_0
  id: goertzel_fc
  parameters:
    freq: '1633'
    len: filter_length
    rate: audio_rate
  states: {}
- name: goertzel_fc_0_0_0_0_0
  id: goertzel_fc
  parameters:
    freq: '697'
    len: filter_length
    rate: audio_rate
  states: {}
- name: goertzel_fc_0_0_0_1
  id: goertzel_fc
  parameters:
    freq: '770'
    len: filter_length
    rate: audio_rate
  states: {}
- name: goertzel_fc_0_0_1
  id: goertzel_fc
  parameters:
    freq: '852'
    len: filter_length
    rate: audio_rate
  states: {}
- name: goertzel_fc_0_1
  id: goertzel_fc
  parameters:
    freq: '941'
    len: filter_length
    rate: audio_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '10'
    size: '128'
    srate: audio_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '6'
    size: '128'
    srate: audio_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/deci1)
    interp: audio_rate
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq_m*1e6
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: igain
    iq_imbal_enb0: '""'
    norm_gain0: 'True'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: low_freqs
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: low_freqs
  states: {}

connections:
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_1, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_and_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_and_xx_0_0, '0', blocks_char_to_float_0_1_0_0, '0']
- [blocks_and_xx_0_0_0, '0', blocks_char_to_float_0_1, '0']
- [blocks_and_xx_0_0_0_0, '0', blocks_char_to_float_0_1_0, '0']
- [blocks_and_xx_0_0_0_0_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_1_0, '0']
- [blocks_and_xx_0_0_0_0_0_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_and_xx_0_0_0_0_0_0_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_1_0, '0']
- [blocks_and_xx_0_0_0_1_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_1, '0']
- [blocks_and_xx_0_0_0_1_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_and_xx_0_0_0_1_0_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_1, '0']
- [blocks_and_xx_0_0_1_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_1_0_0, '0']
- [blocks_and_xx_0_0_1_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_and_xx_0_0_1_0_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_1_0_0, '0']
- [blocks_and_xx_0_1_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_and_xx_0_1_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_and_xx_0_1_0_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '5']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '8']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_1, '0', qtgui_time_sink_x_0, '4']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_1_0, '0', qtgui_time_sink_x_0, '7']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_1_0_0, '0', qtgui_time_sink_x_0, '9']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_1, '0', qtgui_time_sink_x_0_0, '3']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_1_0, '0', qtgui_time_sink_x_0_0, '4']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_1_0_0, '0', qtgui_time_sink_x_0_0, '5']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_0, '3']
- [blocks_char_to_float_0_1_0, '0', qtgui_time_sink_x_0, '6']
- [blocks_char_to_float_0_1_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_threshold_ff_0_0_0_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_threshold_ff_0_2, '0']
- [blocks_complex_to_mag_0_0_0, '0', blocks_threshold_ff_0_1_0, '0']
- [blocks_complex_to_mag_0_0_0_0, '0', blocks_threshold_ff_0_0_1, '0']
- [blocks_complex_to_mag_0_0_0_0_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_complex_to_mag_0_0_0_1, '0', blocks_threshold_ff_0_1, '0']
- [blocks_complex_to_mag_0_0_1, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_0_1, '0', blocks_threshold_ff_0_0_0, '0']
- [blocks_float_to_char_0, '0', blocks_and_xx_0, '1']
- [blocks_float_to_char_0, '0', blocks_and_xx_0_0, '1']
- [blocks_float_to_char_0, '0', blocks_and_xx_0_0_0, '1']
- [blocks_float_to_char_0, '0', blocks_and_xx_0_0_0_0, '1']
- [blocks_float_to_char_0_0, '0', blocks_and_xx_0_0_0_0_0_0_0_0_0, '1']
- [blocks_float_to_char_0_0, '0', blocks_and_xx_0_0_0_1_0_0_0_0, '1']
- [blocks_float_to_char_0_0, '0', blocks_and_xx_0_0_1_0_0_0_0, '1']
- [blocks_float_to_char_0_0, '0', blocks_and_xx_0_1_0_0_0_0, '1']
- [blocks_float_to_char_0_0_0, '0', blocks_and_xx_0_0_0_0_0_0_0, '1']
- [blocks_float_to_char_0_0_0, '0', blocks_and_xx_0_0_0_1_0_0, '1']
- [blocks_float_to_char_0_0_0, '0', blocks_and_xx_0_0_1_0_0, '1']
- [blocks_float_to_char_0_0_0, '0', blocks_and_xx_0_1_0_0, '1']
- [blocks_float_to_char_0_0_0_0, '0', blocks_and_xx_0_0_0_0_0_0_0_0, '1']
- [blocks_float_to_char_0_0_0_0, '0', blocks_and_xx_0_0_0_1_0_0_0, '1']
- [blocks_float_to_char_0_0_0_0, '0', blocks_and_xx_0_0_1_0_0_0, '1']
- [blocks_float_to_char_0_0_0_0, '0', blocks_and_xx_0_1_0_0_0, '1']
- [blocks_float_to_char_0_0_0_0_0, '0', blocks_and_xx_0_0_0, '0']
- [blocks_float_to_char_0_0_0_0_0, '0', blocks_and_xx_0_0_0_1_0_0, '0']
- [blocks_float_to_char_0_0_0_0_0, '0', blocks_and_xx_0_0_0_1_0_0_0, '0']
- [blocks_float_to_char_0_0_0_0_0, '0', blocks_and_xx_0_0_0_1_0_0_0_0, '0']
- [blocks_float_to_char_0_0_0_1, '0', blocks_and_xx_0_0_0_0, '0']
- [blocks_float_to_char_0_0_0_1, '0', blocks_and_xx_0_0_0_0_0_0_0, '0']
- [blocks_float_to_char_0_0_0_1, '0', blocks_and_xx_0_0_0_0_0_0_0_0, '0']
- [blocks_float_to_char_0_0_0_1, '0', blocks_and_xx_0_0_0_0_0_0_0_0_0, '0']
- [blocks_float_to_char_0_0_1, '0', blocks_and_xx_0, '0']
- [blocks_float_to_char_0_0_1, '0', blocks_and_xx_0_1_0_0, '0']
- [blocks_float_to_char_0_0_1, '0', blocks_and_xx_0_1_0_0_0, '0']
- [blocks_float_to_char_0_0_1, '0', blocks_and_xx_0_1_0_0_0_0, '0']
- [blocks_float_to_char_0_1, '0', blocks_and_xx_0_0, '0']
- [blocks_float_to_char_0_1, '0', blocks_and_xx_0_0_1_0_0, '0']
- [blocks_float_to_char_0_1, '0', blocks_and_xx_0_0_1_0_0_0, '0']
- [blocks_float_to_char_0_1, '0', blocks_and_xx_0_0_1_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', goertzel_fc_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', goertzel_fc_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', goertzel_fc_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', goertzel_fc_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', virtual_sink_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_char_0_0_1, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_char_0_0_0_0_0, '0']
- [blocks_threshold_ff_0_0_0, '0', blocks_float_to_char_0_1, '0']
- [blocks_threshold_ff_0_0_0_0, '0', blocks_float_to_char_0, '0']
- [blocks_threshold_ff_0_0_1, '0', blocks_float_to_char_0_0_0_0, '0']
- [blocks_threshold_ff_0_1, '0', blocks_float_to_char_0_0_0_1, '0']
- [blocks_threshold_ff_0_1_0, '0', blocks_float_to_char_0_0_0, '0']
- [blocks_threshold_ff_0_2, '0', blocks_float_to_char_0_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', analog_simple_squelch_cc_0, '0']
- [goertzel_fc_0, '0', blocks_complex_to_mag_0, '0']
- [goertzel_fc_0_0, '0', blocks_complex_to_mag_0_0_0, '0']
- [goertzel_fc_0_0_0, '0', blocks_complex_to_mag_0_0_0_0, '0']
- [goertzel_fc_0_0_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [goertzel_fc_0_0_0_0_0, '0', blocks_complex_to_mag_0_0_1, '0']
- [goertzel_fc_0_0_0_1, '0', blocks_complex_to_mag_0_0_0_0_0, '0']
- [goertzel_fc_0_0_1, '0', blocks_complex_to_mag_0_0_0_1, '0']
- [goertzel_fc_0_1, '0', blocks_complex_to_mag_0_1, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0, '0', goertzel_fc_0_0_0_0_0, '0']
- [virtual_source_0, '0', goertzel_fc_0_0_0_1, '0']
- [virtual_source_0, '0', goertzel_fc_0_0_1, '0']
- [virtual_source_0, '0', goertzel_fc_0_1, '0']

metadata:
  file_format: 1

options:
  parameters:
    author: habets
    generate_options: qt_gui
    id: qpsk_spread_test
    output_language: python
    title: QPSK DSSS
  states: {}

blocks:
- name: air_bw
  id: variable
  parameters:
    value: signal_bw*interpolate
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    label: 'Equalizer: rate'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: slider
  states: {}
- name: freq
  id: variable
  parameters:
    value: '435000000'
  states: {}
- name: igain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: interpolate
  id: variable
  parameters:
    value: int(3000000/(samp_rate*4*sps*spread))
  states: {}
- name: message
  id: variable
  parameters:
    value: '"hello"'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_epsilon
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: noise_frequency_offset
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '5'
  states: {state: disabled}
- name: noise_taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: ogain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: output_sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: signal_bw
  id: variable
  parameters:
    value: samp_rate*4*sps*spread
  states: {}
- name: spread
  id: variable
  parameters:
    value: '20'
  states: {}
- name: spread_delay
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '-spread'
    step: '1'
    stop: spread
    value: '1'
  states: {}
- name: spread_key
  id: variable
  parameters:
    value: '"M0THC"'
  states: {}
- name: spread_key_bits
  id: variable
  parameters:
    value: '[(ord(x)-ord(''0'')) for x in ''''.join([bin(x)[2:].zfill(8) for x in hashlib.sha256(spread_key.encode(''utf-8'')).digest()])]'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: short
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_0_0_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_2_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_3
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_3_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters: {}
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: spread_delay
    type: byte
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: spread
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '20'
    minsize: '10'
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: spread
    type: byte
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {state: disabled}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: '[1,len(message)]'
    type: short
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 4*sps*interpolate*spread*2
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*spread*4*4*interpolate
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: ([1,1,1,1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,1,1,1,1,0,0,1,0,1,0,1,1,1,1,0,0,1,0,0,1,1,0,1,1,0,1,0,1,0]*spread)[:spread]
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[ord(x) for x in message]'
  states: {}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (spread_key_bits*spread)[:spread]
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: blocks_xor_xx_1
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: noise_frequency_offset
    noise_voltage: noise_voltage
    seed: '0'
    taps: noise_taps
  states: {state: disabled}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: eq_gain
    num_taps: '15'
    sps: output_sps
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*3.14/100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: 2*3.14/100
    max_dev: '1.5'
    osps: output_sps
    sps: sps*interpolate
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.01'
    msg_nsamples: air_bw
    type: '0'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, start=1,bits=8,parity=0,stop=1):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='UART Decode',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self._start = start
              self._bits = bits
              self._parity = parity
              self._stop = stop
              self._symbol_size = self._start+self._bits+self._parity+self._stop
              self.state = 'idle'
              self._input_queue = []
              #self.set_min_input_buffer(self._symbol_size*100)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if len(self._input_queue) < self._symbol_size:
                  self._input_queue.append(input_items[0][0])
                  #print("Got bit: %d, total: %s" % (input_items[0][0], self._input_queue))
                  self.consume(0, 1)
                  return 0
              if self._input_queue[0]:
                  self._input_queue.pop(0)
                  return 0
              if self._input_queue[1]:
                  output_items[0][0] |= 1
              if self._input_queue[2]:
                  output_items[0][0] |= 2
              if self._input_queue[3]:
                  output_items[0][0] |= 4
              if self._input_queue[4]:
                  output_items[0][0] |= 8
              if self._input_queue[5]:
                  output_items[0][0] |= 16
              if self._input_queue[6]:
                  output_items[0][0] |= 32
              if self._input_queue[7]:
                  output_items[0][0] |= 64
              if self._input_queue[8]:
                  output_items[0][0] |= 128
              stop = self._input_queue[9]
              self._input_queue = [input_items[0][0]]
              if stop:
                  #print("Decoded: %d" % output_items[0][0])
                  #time.sleep(0.1)
                  return 1
              return 0
    bits: '8'
    parity: '0'
    start: '1'
    stop: '1'
  states: {state: disabled}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: signal_bw
    decim: '1'
    samp_rate: air_bw
    taps: firdes.low_pass(1,air_bw,signal_bw*2,signal_bw//10)
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '-signal_bw'
    decim: '1'
    samp_rate: air_bw
    taps: firdes.low_pass(1,air_bw,signal_bw*4,signal_bw//10)
  states: {}
- name: habets38_uart_decoder_0
  id: habets38_uart_decoder
  parameters:
    bits: '8'
    parity: '0'
    start: '1'
    stop: '1'
  states: {}
- name: habets38_uart_encoder_0
  id: habets38_uart_encoder
  parameters:
    bits: '8'
    parity: '0'
    start: '1'
    stop: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import hashlib
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    ch_align: 'False'
    channel_mode: '0'
    digital_bandw_ch0: air_bw
    gain_dB_ch0: int(73*igain)
    oversample: '0'
    rf_freq: freq
    samp_rate: air_bw
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tabs@0
    name: '"Raw generated"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tabs@0
    name: '"Upsampled"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'tabs@2: 0,1'
    name: '"Clocked"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'tabs@2: 1,1'
    name: '"Frequency locked"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'tabs@2: 1,0'
    name: '"Equalized"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_2
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'tabs@2: 0,0'
    name: '"Air"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate*interpolate*4*sps*spread
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1
    name: '"Air"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 'tabs@2: 0,1'
    label1: Error
    label2: Rate
    label3: Phase
    name: '"Clock Error"'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tabs@3
    marker1: '7'
    name: '"Symbols"'
    size: '128'
    srate: samp_rate*sps/4
    type: float
    ymax: '6'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tabs@3
    marker1: '7'
    name: '"Bit pre spread"'
    size: '128'
    srate: samp_rate*sps
    type: float
    ymax: '5'
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tabs@4: 0,0'
    marker1: '0'
    name: '"TX Bits"'
    size: '10'
    srate: samp_rate*8
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tabs@4: 0,1'
    marker1: '0'
    name: '"RX Bits"'
    size: '10'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: 'tabs@4: 1,1'
    marker1: '0'
    name: '"RX Bytes"'
    size: '10'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: 'tabs@4: 1,0'
    marker1: '0'
    name: '"TX Bytes"'
    size: '10'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: spread//spread
    interp: interpolate
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: interpolate
    interp: spread//spread
    taps: ''
    type: ccc
  states: {state: disabled}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Generation
    label1: Air
    label2: Clocking
    label3: Symbols
    label4: Bits and bytes
    num_tabs: '5'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    dev_args: '""'
    gain0: ogain
    len_tag_name: ''
    norm_gain0: 'True'
    samp_rate: air_bw
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: igain
    iq_imbal_enb0: '""'
    norm_gain0: 'True'
    samp_rate: air_bw
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: air
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: air
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: tx
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: bytes
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: spread_bytes
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: bytes
  states: {state: disabled}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: spreading_bits
  states: {}
- name: virtual_sink_5_0
  id: virtual_sink
  parameters:
    stream_id: spreading_bits
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: tx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: air
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: bytes
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: bytes
  states: {state: disabled}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: air
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: spread_bytes
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: spreading_bits
  states: {}
- name: virtual_source_7
  id: virtual_source
  parameters:
    stream_id: spreading_bits
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_stream_mux_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_2, '0']
- [analog_random_source_x_0_0, '0', digital_constellation_modulator_0, '0']
- [analog_random_source_x_0_0_0, '0', virtual_sink_5_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_char_to_float_2, '0', qtgui_time_sink_x_2, '0']
- [blocks_char_to_float_2_0, '0', qtgui_time_sink_x_2_1, '0']
- [blocks_char_to_float_3, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_char_to_float_3_0, '0', qtgui_time_sink_x_2_0_0, '0']
- [blocks_char_to_short_0, '0', blocks_stream_mux_0, '1']
- [blocks_delay_1, '0', blocks_xor_xx_1, '1']
- [blocks_keep_one_in_n_0, '0', blocks_char_to_float_3, '0']
- [blocks_keep_one_in_n_0, '0', blocks_null_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', epy_block_1, '0']
- [blocks_keep_one_in_n_0, '0', habets38_uart_decoder_0, '0']
- [blocks_message_strobe_0, strobe, blocks_random_pdu_0, generate]
- [blocks_pack_k_bits_bb_1, '0', virtual_sink_3, '0']
- [blocks_pdu_to_tagged_stream_0, '0', virtual_sink_4, '0']
- [blocks_random_pdu_0, pdus, blocks_pdu_to_tagged_stream_0, pdus]
- [blocks_repeat_0, '0', blocks_xor_xx_0, '0']
- [blocks_socket_pdu_0, pdus, blocks_pdu_to_tagged_stream_0, pdus]
- [blocks_stream_mux_0, '0', habets38_uart_encoder_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', uhd_usrp_sink_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_2, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_char_to_float_0_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_xor_xx_1, '0']
- [blocks_vector_source_x_0, '0', virtual_sink_5, '0']
- [blocks_vector_source_x_0_0, '0', virtual_sink_2, '0']
- [blocks_vector_source_x_0_1, '0', virtual_sink_5, '0']
- [blocks_xor_xx_0, '0', blocks_pack_k_bits_bb_1, '0']
- [blocks_xor_xx_1, '0', blocks_keep_one_in_n_0, '0']
- [channels_channel_model_0, '0', virtual_sink_0, '0']
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_cma_equalizer_cc_0, '0', qtgui_const_sink_x_1_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', rational_resampler_xxx_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_1_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_cma_equalizer_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_1, '0']
- [digital_pfb_clock_sync_xxx_0, '1', qtgui_time_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '2', qtgui_time_sink_x_0, '1']
- [digital_pfb_clock_sync_xxx_0, '3', qtgui_time_sink_x_0, '2']
- [digital_probe_mpsk_snr_est_c_0, snr, blocks_message_debug_0, print]
- [epy_block_1, '0', blocks_char_to_float_3_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', virtual_sink_0_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [habets38_uart_decoder_0, '0', blocks_char_to_float_3_0, '0']
- [habets38_uart_encoder_0, '0', blocks_repeat_0, '0']
- [limesdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_const_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_1, '0']
- [rational_resampler_xxx_1, '0', digital_pfb_clock_sync_xxx_0, '0']
- [rational_resampler_xxx_1, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [virtual_source_0, '0', blocks_throttle_0, '0']
- [virtual_source_0_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [virtual_source_1, '0', digital_pfb_clock_sync_xxx_0, '0']
- [virtual_source_1, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [virtual_source_1, '0', rational_resampler_xxx_1, '0']
- [virtual_source_2, '0', blocks_char_to_short_0, '0']
- [virtual_source_3, '0', blocks_char_to_float_2_0, '0']
- [virtual_source_3, '0', blocks_unpack_k_bits_bb_0, '0']
- [virtual_source_4, '0', qtgui_const_sink_x_2, '0']
- [virtual_source_4, '0', qtgui_sink_x_0, '0']
- [virtual_source_5, '0', digital_constellation_modulator_0, '0']
- [virtual_source_6, '0', blocks_xor_xx_0, '1']
- [virtual_source_7, '0', blocks_delay_1, '0']

metadata:
  file_format: 1

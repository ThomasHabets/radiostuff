options:
  parameters:
    author: thompa
    generate_options: qt_gui
    id: ax25_receive
    output_language: python
    title: AX.25 Receive
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: d2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: deci
  id: variable
  parameters:
    value: '4'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '144775000'
  states: {}
- name: igain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: loop_bw
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 0*0.045/2+0*2*3.1415*0.04+0*200e-3+10e-3
  states: {}
- name: noise_frequency_offset
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '0'
  states: {}
- name: noise_voltage
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '0.2'
  states: {}
- name: offset
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: qbw
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '2000'
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: '1.0'
    ntaps: int(11*sps)
    samp_rate: audio_rate/subcarrier_deci
    sym_rate: '1200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: speedup
  id: variable
  parameters:
    value: '10'
  states: {}
- name: sps
  id: variable
  parameters:
    value: audio_rate/subcarrier_deci/1200
  states: {}
- name: sql
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,0
    orient: Qt.Horizontal
    start: '-50'
    step: '1'
    stop: '0'
    value: '0'
  states: {}
- name: subcarrier_deci
  id: variable
  parameters:
    value: '1'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0.1'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {state: disabled}
- name: analog_agc_xx_1
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate//deci
    max_dev: 5e3
    quad_rate: samp_rate//deci
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'False'
    ramp: '0'
    threshold: sql
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: aprs1200_50ksps.raw
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: aprs1200_50ksps.raw
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: d2
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: int(speedup*samp_rate//deci)
    type: complex
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: noise_frequency_offset
    noise_voltage: noise_voltage
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.005'
    type: float
  states: {state: disabled}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '''''.join([str(x) for x in [1,1,1,1,1,1,1,0]*3][:-1])'
    comment: |-
      The tag seems to be put one bit too late,
      so shortening the CAC by one bit
    tagname: packet_start
    threshold: '0'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '''''.join(str(1-x) for x in [1,1,1,1,1,1,1,0]*3)'
    tagname: packet_end
    threshold: '0'
    type: byte
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: '62.8e-3'
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: fff
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '2.0'
    loop_bw: loop_bw
    max_dev: 1*1.5
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '2'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """AX25 decoder block

      This block takes an input stream with a burst starting with one tag
      and ending with another.

      It then takes those bits, NRZ unscrambles them, and decodes the bytes
      as LSB by bytes.
      """

      import numpy as np
      import time
      import tempfile
      from gnuradio import gr
      from gnuradio.gr import pmt

      # other base classes are basic_block, decim_block, interp_block
      class blk(gr.basic_block):
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, start_tag="start", stop_tag="stop"):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self._data = []
              self._active = False
              self._start = start_tag
              self._stop = stop_tag
              self._pub = pmt.intern("bits")
              self.message_port_register_out(self._pub)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              inp = input_items[0]

              tags = self.get_tags_in_window(0, 0, len(inp))
              tagmap = {}
              nr = self.nitems_read(0)
              for tag in tags:
                  key = pmt.to_python(tag.key)
                  tagmap.setdefault(tag.offset-nr, set()).add(key)
              #print(len(inp), tagmap)
              for ind, sample in enumerate(inp):
                  if self._start in tagmap.get(ind, set()):
                      # packet
                      self._data = []
                      self._active = True
                  if not self._active:
                      continue
                  self._data.append(int(sample))
                  if self._data and self._stop in tagmap.get(ind, set()):
                      # packet
                      bits = []
                      for n in range(1, len(self._data)):
                          bits.append(1 ^ self._data[n] ^ self._data[n-1])
                      #self.message_port_pub(self._pub, pmt.to_pmt(self._data))
                      #print(bits)
                      bits = self._truncate(bits)
                      if len(bits):
                          bits = self._unstuff(bits)
                          byt = self._pack(bits)
                          #print("HABETS packet arrived. size %d -> %d" % (len(bits), len(byt)))
                          self.message_port_pub(self._pub, pmt.to_pmt(byt))
                          with open('%s/ax25-%s.raw' % (tempfile.gettempdir(), str(time.time())), 'wb') as f:
                              f.write(b''.join([x.to_bytes(1,byteorder='big') for x in byt]))
                      self._active = False
                      self._data = []
              self.consume(0, len(inp))
              return len(output_items)

          def _truncate(self, bits):
              a = ''.join(str(b) for b in bits)
              i = a.find('01111110')
              if i < 0:
                  # No packet end flag.
                  return []
              return bits[:i]
          
          def _unstuff(self, bits):
              out = []
              n = 0
              for b in bits:
                  assert b < 6
                  if b:
                      n += 1
                  else:
                      if n == 5:
                          n = 0
                          continue
                      n = 0
                  out.append(b)
              return out

          def _pack(self, bits):
              byt = []
              while len(bits) > 8:
                  b, bits = bits[:8], bits[8:]
                  t = 1
                  by = 0
                  for sym in b:
                      if sym:
                          by += t
                      t *= 2
                  if byt == 0x7E:
                      break
                  byt.append(by)
              return byt
                  

      """
      B: 12345678  87654321
      --
      M: 10011010  01011001
      0: 01100000  00000110
      T: 10101000  00010101
      H: 10010000  00001001
      C: 10000110  01100001
       : 01000000  00000010
      A: 10000010  01000001
      """
    start_tag: '''packet_start'''
    stop_tag: '''squelch_eob'''
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: offset
    decim: deci
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 12500,1000)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 1200+(2200-1200)//2
    decim: subcarrier_deci
    samp_rate: audio_rate
    taps: firdes.low_pass(1,audio_rate,1200,100)
    type: fcc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: qbw
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Audio"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate//subcarrier_deci
    fc: '0'
    fftsize: '1024'
    name: '"Subcarrier"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Filtered"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Audio"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 1,0,1,2
    name: '"Bits"'
    size: int(1200)
    srate: '1200'
    tr_delay: '1e-3'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_start"'
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 0,1
    label1: Signal
    label2: Error
    label3: T inst
    label4: T avg
    marker1: '0'
    name: '"Clocked"'
    nconnections: '4'
    size: int(1.5*1200)
    srate: '1200'
    tr_delay: '100e-3'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 0,0
    label1: Signal
    marker1: '0'
    name: '"Subcarrier quad demod"'
    size: int(1.5*audio_rate//subcarrier_deci/d2)
    srate: audio_rate//subcarrier_deci//d2
    tr_delay: '100e-3'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Signal
    label2: Error
    label3: T inst
    label4: T avg
    marker1: '0'
    name: '"Polyphase clock synced"'
    nconnections: '4'
    size: int(1.5*1200)
    srate: '1200'
    tr_delay: '100e-3'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Signal
    marker1: '0'
    name: '"MM synced"'
    size: int(1.5*1200)
    srate: '1200'
    tr_delay: '100e-3'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate//deci
    interp: audio_rate
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate
    center_freq0: freq-offset
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: igain
    iq_imbal_enb0: '""'
    norm_gain0: 'True'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: filtered
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: audio
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: subcarrier
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: quad
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: symbols
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: bits
  states: {}
- name: virtual_sink_6
  id: virtual_sink
  parameters:
    stream_id: captured
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: filtered
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: audio
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: subcarrier
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: quad
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: symbols
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: bits
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: captured
  states: {}

connections:
- [analog_agc_xx_0, '0', virtual_sink_3, '0']
- [analog_agc_xx_1, '0', channels_channel_model_0, '0']
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_0, '0']
- [analog_pwr_squelch_xx_0, '0', virtual_sink_0, '0']
- [analog_quadrature_demod_cf_0, '0', analog_agc_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0, '0']
- [analog_quadrature_demod_cf_0, '0', virtual_sink_3, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_throttle_0, '0', virtual_sink_6, '0']
- [channels_channel_model_0, '0', analog_pwr_squelch_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_time_sink_x_1_0_1_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', digital_correlate_access_code_tag_xx_0_0, '0']
- [digital_correlate_access_code_tag_xx_0_0, '0', blocks_char_to_float_0, '0']
- [digital_correlate_access_code_tag_xx_0_0, '0', virtual_sink_5, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_time_sink_x_1_0_1, '0']
- [digital_pfb_clock_sync_xxx_0, '1', qtgui_time_sink_x_1_0_1, '1']
- [digital_pfb_clock_sync_xxx_0, '2', qtgui_time_sink_x_1_0_1, '2']
- [digital_pfb_clock_sync_xxx_0, '3', qtgui_time_sink_x_1_0_1, '3']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_1_0, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_4, '0']
- [digital_symbol_sync_xx_0, '1', qtgui_time_sink_x_1_0, '1']
- [digital_symbol_sync_xx_0, '2', qtgui_time_sink_x_1_0, '2']
- [digital_symbol_sync_xx_0, '3', qtgui_time_sink_x_1_0, '3']
- [epy_block_0, bits, blocks_message_debug_0, print]
- [freq_xlating_fft_filter_ccc_0, '0', blocks_file_sink_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', virtual_sink_6, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', virtual_sink_2, '0']
- [low_pass_filter_0, '0', virtual_sink_3, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_1, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [virtual_source_0, '0', analog_nbfm_rx_0, '0']
- [virtual_source_0, '0', qtgui_sink_x_0, '0']
- [virtual_source_1, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_2, '0', analog_quadrature_demod_cf_0, '0']
- [virtual_source_2, '0', qtgui_freq_sink_x_1, '0']
- [virtual_source_3, '0', blocks_keep_one_in_n_0, '0']
- [virtual_source_3, '0', digital_clock_recovery_mm_xx_0, '0']
- [virtual_source_3, '0', digital_pfb_clock_sync_xxx_0, '0']
- [virtual_source_3, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_4, '0', digital_binary_slicer_fb_0, '0']
- [virtual_source_5, '0', epy_block_0, '0']
- [virtual_source_6, '0', analog_agc_xx_1, '0']

metadata:
  file_format: 1

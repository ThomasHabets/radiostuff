options:
  parameters:
    author: thomas@habets.se
    category: habets
    generate_options: hb_qt_gui
    id: modem_fsk
    output_language: python
    title: FSK modem
  states: {}

blocks:
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: baud
  id: parameter
  parameters:
    type: intx
    value: '1200'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10000'
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: samp_rate//baud
    type: float
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 2*math.pi
  states: {}
- name: blocks_xor_xx_0_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '500'
    min: '4'
  states: {}
- name: digital_hdlc_framer_pb_0
  id: digital_hdlc_framer_pb
  parameters:
    frame_tag_name: frame
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_rate/baud
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio.gr import pmt

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='PDU prepender',
                  in_sig=[],
                  out_sig=[]
              )
              self._in = pmt.intern("in")
              self._out = pmt.intern("out")
              self.message_port_register_in(self._in)
              self.message_port_register_out(self._out)
              self.set_msg_handler(self._in, self.handle_msg)

          def handle_msg(self, msg):
              val = pmt.to_python(pmt.cdr(msg))
              val = [1,0] * 40 + list(val) + [1,0] * 10
              self.message_port_pub(self._out, pmt.cons(pmt.car(msg),
                                                        pmt.init_u8vector(len(val), val)))
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio.gr import pmt

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Scrambler',
                  in_sig=[],
                  out_sig=[]
              )
              self._in = pmt.intern("in")
              self._out = pmt.intern("out")
              self.message_port_register_in(self._in)
              self.message_port_register_out(self._out)
              self.set_msg_handler(self._in, self.handle_msg)

          def handle_msg(self, msg):
              val = pmt.to_python(pmt.cdr(msg))
              last = 0
              for n in range(len(val)):
                  val[n] ^= last
                  last = val[n]
              self.message_port_pub(self._out, pmt.cons(pmt.car(msg),
                                                        pmt.init_u8vector(len(val), val)))
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '120'
    samp_rate: samp_rate
    sym_rate: baud
    type: fff
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '5000'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,20000,1000)
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '128'
    win: window.WIN_BLACKMAN_hARRIS
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: outpdu
    type: message
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: outrf
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: inpdu
    type: message
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: inrf
    type: complex
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: frame
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@0
    size: int(baud*200e-3)
    srate: baud
    tr_delay: '10e-3'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@1
    marker1: '2'
    name: '"RX clocked"'
    size: int(baud*200e-3)
    srate: baud
    tr_delay: '10e-3'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@1
    name: '"RX Quad"'
    size: int(samp_rate*200e-3)
    srate: samp_rate
    tr_delay: '10e-3'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame"'
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@1
    marker1: '7'
    name: '"RX sliced"'
    size: int(baud*200e-3)
    srate: baud
    tr_delay: '10e-3'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame"'
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tabs@1
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: intx
    value: '200000'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: TX
    label1: RX
    num_tabs: '2'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', filter_fft_rrc_filter_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_repeat_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_delay_0_0, '0', blocks_xor_xx_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_repeat_0, '0', blocks_vco_f_0, '0']
- [blocks_vco_f_0, '0', hilbert_fc_0, '0']
- [blocks_xor_xx_0_0, '0', digital_hdlc_deframer_bp_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_1, '0']
- [digital_binary_slicer_fb_0, '0', blocks_delay_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_xor_xx_0_0, '0']
- [digital_hdlc_deframer_bp_0, out, pad_sink_0, in]
- [digital_hdlc_framer_pb_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [epy_block_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_1, out, epy_block_0, in]
- [filter_fft_rrc_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [filter_fft_rrc_filter_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', pad_sink_1, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [hilbert_fc_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [pad_source_0, out, digital_hdlc_framer_pb_0, in]
- [pad_source_1, '0', analog_quadrature_demod_cf_0, '0']
- [pad_source_1, '0', qtgui_time_sink_x_1, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_char_to_float_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_1, in]

metadata:
  file_format: 1

options:
  parameters:
    author: thomas@habets.se
    category: habets
    generate_options: hb_qt_gui
    id: modem_ax1200
    output_language: python
    title: AX1200 modem
  states: {}

blocks:
- name: intermediate_samp_rate
  id: variable
  parameters:
    value: audio_rate*(samp_rate//audio_rate)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: TX Volume
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: intermediate_samp_rate
    tau: '75e-6'
  states: {}
- name: audio_rate
  id: parameter
  parameters:
    type: intx
    value: '12000'
  states: {}
- name: ax25_hier_rx_ng_0
  id: ax25_hier_rx_ng
  parameters:
    audio_rate: audio_rate
    bps: baud
    gui_hint: tabs@1
    max_packet: max_packet
    min_packet: min_packet
    samp_rate: samp_rate
  states: {}
- name: baud
  id: parameter
  parameters:
    type: intx
    value: '1200'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1200'
    type: float
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1000'
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: audio_rate//baud
    type: float
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: volume
    samp_rate: audio_rate
    sensitivity: 2*math.pi
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: digital_hdlc_framer_pb_0
  id: digital_hdlc_framer_pb
  parameters:
    frame_tag_name: frame
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio.gr import pmt

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='PDU prepender',
                  in_sig=[],
                  out_sig=[]
              )
              self._in = pmt.intern("in")
              self._out = pmt.intern("out")
              self.message_port_register_in(self._in)
              self.message_port_register_out(self._out)
              self.set_msg_handler(self._in, self.handle_msg)

          def handle_msg(self, msg):
              sync = [0, 1,1,1, 1,1,1, 0]
              usync = [(1-x) for x in sync]
              val = pmt.to_python(pmt.cdr(msg))
              val = sync * 20 + list(val) + sync * 10 + [0] * 100
              self.message_port_pub(self._out, pmt.cons(pmt.car(msg),
                                                        pmt.init_u8vector(len(val), val)))
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio.gr import pmt

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Scrambler',
                  in_sig=[],
                  out_sig=[]
              )
              self._in = pmt.intern("in")
              self._out = pmt.intern("out")
              self.message_port_register_in(self._in)
              self.message_port_register_out(self._out)
              self.set_msg_handler(self._in, self.handle_msg)

          def handle_msg(self, msg):
              val = pmt.to_python(pmt.cdr(msg))
              last = 0
              for n in range(len(val)):
                  val[n] ^= 1 ^ last
                  last = val[n]
              self.message_port_pub(self._out, pmt.cons(pmt.car(msg),
                                                        pmt.init_u8vector(len(val), val)))
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '25000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: max_packet
  id: parameter
  parameters:
    type: intx
    value: '500'
  states: {}
- name: min_packet
  id: parameter
  parameters:
    type: intx
    value: '32'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: pduout
    type: message
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: outrf
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: pduin
    type: message
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: inrf
    type: complex
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: frame
    type: byte
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tabs@0
    name: '"Generated bits"'
    size: baud
    srate: baud
    tr_delay: '50e-3'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '2'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: intermediate_samp_rate
    interp: samp_rate
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: intx
    value: '200000'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Generator
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: txbits
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: txbits
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_xor_xx_0, '0']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [ax25_hier_rx_ng_0, out, pad_sink_0, in]
- [blocks_add_const_vxx_0, '0', blocks_repeat_0, '0']
- [blocks_char_to_float_0_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_repeat_0, '0', blocks_vco_f_0, '0']
- [blocks_vco_f_0, '0', analog_nbfm_tx_0, '0']
- [blocks_xor_xx_0, '0', virtual_sink_0, '0']
- [digital_hdlc_framer_pb_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [epy_block_0, out, epy_block_1, in]
- [epy_block_1, out, pdu_pdu_to_tagged_stream_0, pdus]
- [low_pass_filter_0, '0', pad_sink_1, '0']
- [pad_source_0, out, digital_hdlc_framer_pb_0, in]
- [pad_source_1, '0', ax25_hier_rx_ng_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_xor_xx_0, '1']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_0, in]
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [virtual_source_0, '0', blocks_char_to_float_0_1, '0']

metadata:
  file_format: 1

options:
  parameters:
    author: thompa
    generate_options: qt_gui
    id: modem_ax9600_rr
    output_language: python
    title: AX.25 9600bps multimodem
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: cutoff
  id: variable_qtgui_entry
  parameters:
    gui_hint: tabs@1
    type: int
    value: '12300'
  states: {}
- name: deci
  id: variable
  parameters:
    value: '10'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0
    type: int
    value: '144400000'
  states: {}
- name: igain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,2
    type: real
    value: '0.3'
  states: {}
- name: ogain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1
    type: real
    value: '0.3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: ax25_hier_rx_0
  id: ax25_hier_rx
  parameters:
    audio_rate: '12000'
    bps: '1200'
    gui_hint: tabs@0
    samp_rate: samp_rate//deci//4
  states: {}
- name: ax25_hier_rx_0_0
  id: ax25_hier_rx
  parameters:
    audio_rate: '12000'
    bps: '1200'
    gui_hint: tabs@0
    samp_rate: samp_rate//deci//4
  states: {}
- name: ax25_hier_rx_0_1
  id: ax25_hier_rx
  parameters:
    audio_rate: '12000'
    bps: '1200'
    gui_hint: tabs@0
    samp_rate: samp_rate//deci//4
  states: {}
- name: ax25_hier_rx_0_2
  id: ax25_hier_rx
  parameters:
    audio_rate: '12000'
    bps: '1200'
    gui_hint: tabs@0
    samp_rate: samp_rate//deci//4
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio.gr import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, outputs=3):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Message mux',   # will show up in GRC
                  in_sig=[],
                  out_sig=[]
              )
              self._in = pmt.intern("in")
              self.message_port_register_in(self._in)
              self.set_msg_handler(self._in, self.handle_msg)
              for i in range(outputs):
                  self.message_port_register_out(pmt.intern('out%d' % i))
              self._current = 0
              self.outputs = outputs

          def handle_msg(self, msg):
              self.message_port_pub(pmt.intern('out%d' % self._current), msg)
              self._current = (self._current + 1) % self.outputs
              
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * 1
              return len(output_items[0])
    outputs: '3'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import time

      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, streams=2):
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Packet blender',   # will show up in GRC
                  in_sig=streams*[np.complex64],
                  out_sig=streams*[np.complex64]
              )
              self.input_sizes = streams*[0]

          def general_work(self, input_items, output_items):
              """example: multiply with constant"""

              print("1")
              with_data = [n for n,x in enumerate(input_items) if len(x) > 0]
              print("2")
              for n in [x for x in with_data if self.input_sizes[x] == 0]:
                  tags = self.get_tags_in_window(n, 0, 1)
                  print(n, tags)
              print("3")
              time.sleep(1)
              active = [n for n,x in enumerate(self.input_sizes) if x > 0]

              if not active:
                  print("Should not happen")
                  time.sleep(1)
                  return 0

              mi = min(active)
              for n, size in enumerate(self.input_sizes):
                  if size > 0:
                      self.output_items[n][:] = input_items[n][:mi]
                      self.consume(n, mi)
                  else:
                      self.output_items[n][:] = mi * [0]
              return len(output_items[0])
    streams: '2'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class blk(gr.basic_block):
          """Embedded Python Block example"""

          def __init__(self):
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Zerogate',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self._packet_remaining = 0

          def general_work(self, input_items, output_items):
              """Produce outputs"""
              print("HELLO")
              if self._packet_remaining:
                  n = min(self._packet_remaining, len(input_items[0]))
                  output_items[0][:n] = input_items[0][:n]
                  self.consume(0, n)
                  return n
              print("HABETS",output_items)
              print("HABETS",len(output_items[0]))
              output_items[0][:] = [0] * len(output_items[0])
              self.consume(0, len(input_items[0]))
              return len(output_items[0])
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: ''
  states: {state: disabled}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '0'
    decim: deci
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,49700,100)
  states: {}
- name: modem_ax9600_grsat_hier_rx_0
  id: modem_ax9600_grsat_hier_rx
  parameters:
    baud: baud
    samp_rate: samp_rate//deci//4
  states: {}
- name: modem_ax9600_grsat_hier_rx_0_0
  id: modem_ax9600_grsat_hier_rx
  parameters:
    baud: baud
    samp_rate: samp_rate//deci//4
  states: {}
- name: modem_ax9600_grsat_hier_rx_0_0_0
  id: modem_ax9600_grsat_hier_rx
  parameters:
    baud: baud
    samp_rate: samp_rate//deci//4
  states: {}
- name: modem_ax9600_grsat_hier_rx_0_1
  id: modem_ax9600_grsat_hier_rx
  parameters:
    baud: baud
    samp_rate: samp_rate//deci//4
  states: {}
- name: modem_ax9600_grsat_hier_tx_0
  id: modem_ax9600_grsat_hier_tx
  parameters:
    sps: sps
  states: {}
- name: modem_ax9600_grsat_hier_tx_0_0
  id: modem_ax9600_grsat_hier_tx
  parameters:
    sps: sps
  states: {}
- name: modem_ax9600_grsat_hier_tx_0_1
  id: modem_ax9600_grsat_hier_tx
  parameters:
    sps: sps
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52002'
    type: UDP_CLIENT
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[0,1,3,2]'
    nchans: '4'
    osr: '1.0'
    taps: firdes.low_pass(1,samp_rate//deci,12000,100)
  states: {}
- name: pfb_synthesizer_ccf_1
  id: pfb_synthesizer_ccf
  parameters:
    ch_map: '[0,1,3,2]'
    connections: '4'
    numchans: '4'
    taps: firdes.low_pass(1,25000*4,cutoff,100)
    twox: 'False'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 'tabs@0: 2,0,1,2'
    name: '"Channel 0"'
    size: samp_rate//deci//4
    srate: samp_rate//deci//4
    tr_delay: '0.1'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 'tabs@0: 2,2,1,2'
    name: '"Channel 1"'
    size: samp_rate//deci//4
    srate: samp_rate//deci//4
    tr_delay: '0.1'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1
    name: '"Air"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate//deci
    fc: '0'
    fftsize: '1024'
    gui_hint: 'tabs@0: 0,0,1,4'
    name: '"100kHz filtered"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 25000*4
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1
    name: '"TX channels"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '25000'
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1
    name: '"Channel 0"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate//deci//4
    fc: '0'
    fftsize: '1024'
    gui_hint: 'tabs@0: 1,0'
    name: '"Channel 0"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate//deci//4
    fc: '0'
    fftsize: '1024'
    gui_hint: 'tabs@0: 1,2'
    name: '"Channel 2"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate//deci//4
    fc: '0'
    fftsize: '1024'
    gui_hint: 'tabs@0: 1,3'
    name: '"Channel 3"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate//deci//4
    fc: '0'
    fftsize: '1024'
    gui_hint: 'tabs@0: 1,1'
    name: '"Channel 1"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: 25000*4
    interp: samp_rate
    type: ccc
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: RX
    label1: TX
    num_tabs: '2'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: ogain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    gain0: igain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: to_air
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: from_air
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: to_air
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: from_air
  states: {}

connections:
- [analog_const_source_x_0, '0', pfb_synthesizer_ccf_1, '3']
- [analog_noise_source_x_0, '0', blocks_throttle2_0_1, '0']
- [ax25_hier_rx_0, out, blocks_message_debug_0, print]
- [ax25_hier_rx_0, out, network_socket_pdu_0_0, pdus]
- [ax25_hier_rx_0_0, out, blocks_message_debug_0, print]
- [ax25_hier_rx_0_0, out, network_socket_pdu_0_0, pdus]
- [ax25_hier_rx_0_1, out, blocks_message_debug_0, print]
- [ax25_hier_rx_0_1, out, network_socket_pdu_0_0, pdus]
- [ax25_hier_rx_0_2, out, blocks_message_debug_0, print]
- [ax25_hier_rx_0_2, out, network_socket_pdu_0_0, pdus]
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_1, '0']
- [blocks_throttle2_0_1, '0', freq_xlating_fft_filter_ccc_0, '0']
- [epy_block_0, out0, modem_ax9600_grsat_hier_tx_0, in]
- [epy_block_0, out1, modem_ax9600_grsat_hier_tx_0_0, in]
- [epy_block_0, out2, modem_ax9600_grsat_hier_tx_0_1, in]
- [freq_xlating_fft_filter_ccc_0, '0', pfb_channelizer_ccf_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [modem_ax9600_grsat_hier_rx_0, out, blocks_message_debug_0, print]
- [modem_ax9600_grsat_hier_rx_0, out, network_socket_pdu_0_0, pdus]
- [modem_ax9600_grsat_hier_rx_0_0, out, network_socket_pdu_0_0, pdus]
- [modem_ax9600_grsat_hier_rx_0_0_0, out, network_socket_pdu_0_0, pdus]
- [modem_ax9600_grsat_hier_rx_0_1, out, network_socket_pdu_0_0, pdus]
- [modem_ax9600_grsat_hier_tx_0, '0', pfb_synthesizer_ccf_1, '0']
- [modem_ax9600_grsat_hier_tx_0, '0', qtgui_waterfall_sink_x_1_0, '0']
- [modem_ax9600_grsat_hier_tx_0_0, '0', pfb_synthesizer_ccf_1, '1']
- [modem_ax9600_grsat_hier_tx_0_1, '0', pfb_synthesizer_ccf_1, '2']
- [network_socket_pdu_0, pdus, epy_block_0, in]
- [pfb_channelizer_ccf_0, '0', ax25_hier_rx_0, '0']
- [pfb_channelizer_ccf_0, '0', modem_ax9600_grsat_hier_rx_0, '0']
- [pfb_channelizer_ccf_0, '0', qtgui_time_sink_x_0, '0']
- [pfb_channelizer_ccf_0, '0', qtgui_waterfall_sink_x_1_0_0, '0']
- [pfb_channelizer_ccf_0, '1', ax25_hier_rx_0_0, '0']
- [pfb_channelizer_ccf_0, '1', modem_ax9600_grsat_hier_rx_0_0, '0']
- [pfb_channelizer_ccf_0, '1', qtgui_time_sink_x_0_0, '0']
- [pfb_channelizer_ccf_0, '1', qtgui_waterfall_sink_x_1_2, '0']
- [pfb_channelizer_ccf_0, '2', ax25_hier_rx_0_1, '0']
- [pfb_channelizer_ccf_0, '2', modem_ax9600_grsat_hier_rx_0_1, '0']
- [pfb_channelizer_ccf_0, '2', qtgui_waterfall_sink_x_1_1, '0']
- [pfb_channelizer_ccf_0, '3', ax25_hier_rx_0_2, '0']
- [pfb_channelizer_ccf_0, '3', modem_ax9600_grsat_hier_rx_0_0_0, '0']
- [pfb_channelizer_ccf_0, '3', qtgui_waterfall_sink_x_1_1_0, '0']
- [pfb_synthesizer_ccf_1, '0', qtgui_waterfall_sink_x_1, '0']
- [pfb_synthesizer_ccf_1, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_0, '0']
- [uhd_usrp_source_0, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0, '0', uhd_usrp_sink_0, '0']
- [virtual_source_1, '0', freq_xlating_fft_filter_ccc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0

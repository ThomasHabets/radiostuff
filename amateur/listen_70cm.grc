options:
  parameters:
    author: Thomas Habets <thomas@habets.se>
    copyright: Thomas Habets <thomas@habets.se>
    generate_options: qt_gui
    id: listen_70cm
    output_language: python
    title: Amateur radio 70cm listener
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: deci0
  id: variable
  parameters:
    value: '1'
  states: {}
- name: deci1
  id: variable
  parameters:
    value: '30'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '435000000'
  states: {}
- name: igain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.6'
  states: {}
- name: probed_value
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0
    function_name: level
    poll_rate: '5'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: squelsh_level
  id: variable_qtgui_range
  parameters:
    label: Squelsh
    orient: Qt.Horizontal
    start: '-200'
    step: '1'
    stop: '0'
    value: '-68'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    type: int
    value: '0'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(samp_rate/deci0/deci1)
    max_dev: 5e3
    quad_rate: int(samp_rate/deci0/deci1)
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelsh_level
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: fft_size
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '100'
    max_iter: '4000'
    scale: '1'
    type: float
    vlen: fft_size
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: deci0
    taps: firdes.low_pass(1,samp_rate,4985000,500)
    type: ccc
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: samp_rate/deci0*(probed_value-fft_size/2)/fft_size
    decim: deci1
    samp_rate: samp_rate/deci0
    taps: firdes.low_pass(1,samp_rate/deci0,12500,500)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate/deci0
    type: float
    ymax: fft_size
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/deci0
    fc: freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/deci0/deci1
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/deci0/deci1)
    interp: audio_rate
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    dc_offs_enb0: '""'
    gain0: igain
    iq_imbal_enb0: '""'
    norm_gain0: 'True'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_argmax_xx_0, '0', blocks_short_to_float_0, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_argmax_xx_0, '0']
- [blocks_short_to_float_0, '0', blocks_probe_signal_x_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_filter_xxx_0, '0', blocks_stream_to_vector_0, '0']
- [fft_filter_xxx_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [fft_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_waterfall_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [uhd_usrp_source_0, '0', fft_filter_xxx_0, '0']

metadata:
  file_format: 1

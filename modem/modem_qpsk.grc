options:
  parameters:
    author: thomas@habets.se
    category: habets
    generate_options: hb_qt_gui
    id: modem_qpsk
    output_language: python
    title: QPSK modem
  states: {}

blocks:
- name: cons
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: silence_len
  id: variable
  parameters:
    value: '50'
  states: {}
- name: silence_tag
  id: variable_tag_object
  parameters:
    key: pmt.intern("packet_len")
    offset: '0'
    src: pmt.intern("src")
    value: pmt.to_pmt(silence_len)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: baud
  id: parameter
  parameters:
    type: intx
    value: '1200'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps*4
    lengthtagname: '"packet_len"'
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1/8
    lengthtagname: '"packet_len"'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: cons
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: cons
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
    truncate: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '500'
    min: '4'
  states: {}
- name: digital_hdlc_framer_pb_0
  id: digital_hdlc_framer_pb
  parameters:
    frame_tag_name: frame
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps*(samp_rate/baud)
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio.gr import pmt

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='PDU prepender',
                  in_sig=[],
                  out_sig=[]
              )
              self._in = pmt.intern("in")
              self._out = pmt.intern("out")
              self.message_port_register_in(self._in)
              self.message_port_register_out(self._out)
              self.set_msg_handler(self._in, self.handle_msg)

          def handle_msg(self, msg):
              val = pmt.to_python(pmt.cdr(msg))
              val = [1,0] * 40 + list(val) + [1,0] * 10
              self.message_port_pub(self._out, pmt.cons(pmt.car(msg),
                                                        pmt.init_u8vector(len(val), val)))
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio.gr import pmt

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Scrambler',
                  in_sig=[],
                  out_sig=[]
              )
              self._in = pmt.intern("in")
              self._out = pmt.intern("out")
              self.message_port_register_in(self._in)
              self.message_port_register_out(self._out)
              self.set_msg_handler(self._in, self.handle_msg)

          def handle_msg(self, msg):
              val = pmt.to_python(pmt.cdr(msg))
              last = 0
              for n in range(len(val)):
                  val[n] ^= last
                  last = val[n]
              self.message_port_pub(self._out, pmt.cons(pmt.car(msg),
                                                        pmt.init_u8vector(len(val), val)))
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nfrom gnuradio.gr import pmt\n\nclass blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='PDU Pad',   # will show up in GRC\n            in_sig=[],\n            out_sig=[]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self._in = pmt.intern(\"in\")\n        self._out = pmt.intern(\"out\")\n        self.message_port_register_in(self._in)\n        self.message_port_register_out(self._out)\n        self.set_msg_handler(self._in, self.handle_msg)\n\n    def handle_msg(self, msg):\n        val = list(pmt.to_python(pmt.cdr(msg)))\n        val += [0] * (8 - (len(val) % 8))\n        self.message_port_pub(self._out, pmt.cons(pmt.car(msg),\n                                                  pmt.init_u8vector(len(val), val)))\n                                                  \n"
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: pduout
    type: message
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: outrf
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: pduin
    type: message
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: inrf
    type: complex
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: frame
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"Generated bytes"'
    size: baud
    srate: baud
    tr_delay: '50e-3'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '128'
    ymin: '-128'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"Modulated"'
    size: baud
    srate: baud
    tr_delay: '50e-3'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '7'
    name: '"Received bits"'
    size: baud
    srate: baud
    tr_delay: '50e-3'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"Generated bits"'
    size: baud
    srate: baud
    tr_delay: '50e-3'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '2'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: baud
    interp: samp_rate
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: intx
    value: '12000'
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_delay_0, '0', blocks_xor_xx_0, '1']
- [blocks_pack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', rational_resampler_xxx_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', digital_constellation_modulator_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_delay_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_xor_xx_0, '0']
- [blocks_xor_xx_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_xor_xx_0, '0', digital_hdlc_deframer_bp_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_hdlc_deframer_bp_0, out, pad_sink_0, in]
- [digital_hdlc_framer_pb_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_map_bb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [epy_block_0, out, epy_block_2, in]
- [epy_block_1, out, epy_block_0, in]
- [epy_block_2, out, pdu_pdu_to_tagged_stream_0, pdus]
- [pad_source_0, out, digital_hdlc_framer_pb_0, in]
- [pad_source_1, '0', digital_symbol_sync_xx_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_char_to_float_0_1, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_pack_k_bits_bb_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_1, in]
- [rational_resampler_xxx_0, '0', pad_sink_1, '0']

metadata:
  file_format: 1

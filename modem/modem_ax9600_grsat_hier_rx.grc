options:
  parameters:
    author: thomas@habets.se
    category: '[habets]'
    generate_options: hb
    id: modem_ax9600_grsat_hier_rx
    output_language: python
    title: 9600bps AX.25 receiver
  states: {}

blocks:
- name: baud
  id: parameter
  parameters:
    label: Baud rate
    type: intx
    value: '9600'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: intx
    value: '1000000'
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud
    iq: 'True'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}

connections:
- [pad_source_0, '0', satellites_fsk_demodulator_0, '0']
- [satellites_ax25_deframer_0, out, pad_sink_0, in]
- [satellites_fsk_demodulator_0, '0', satellites_ax25_deframer_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0

options:
  parameters:
    author: thomas@habets.se
    category: habets
    generate_options: hb_qt_gui
    id: modem_bell103
    output_language: python
    title: Bell 103 modem
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '300'
  states: {}
- name: freq_mark
  id: variable
  parameters:
    value: '1270'
  states: {}
- name: freq_space
  id: variable
  parameters:
    value: '1070'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/baud
  states: {}
- name: test_message
  id: variable
  parameters:
    value: '"The quick brown fox jumped over the lazy dog 1234567890"'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: freq_space
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: 1.0/(freq_mark-freq_space)
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(test_message), [ord(x) for x in test_message]))
    period: '100'
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: samp_rate//baud
    type: float
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '0.3'
    samp_rate: baud*sps
    sensitivity: 2*math.pi
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_hdlc_deframer_bp_1
  id: digital_hdlc_deframer_bp
  parameters:
    max: '500'
    min: '32'
  states: {}
- name: digital_hdlc_framer_pb_0
  id: digital_hdlc_framer_pb
  parameters:
    frame_tag_name: frame
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.complex_band_pass(1,samp_rate, 0,2000,100)
    type: ccc
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: freq_space+(freq_mark-freq_space)/2
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 300,300)
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
    win: window.WIN_BLACKMAN
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: outrf
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: pduout
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: pduin
    type: message
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: inrf
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"TX Bits"'
    size: baud
    srate: baud
    tr_delay: '100e-3'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame"'
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Quad"'
    size: samp_rate
    srate: samp_rate
    tr_delay: '100e-3'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame"'
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"Freqs"'
    size: samp_rate
    srate: samp_rate
    tr_delay: '100e-3'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame"'
    type: float
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    name: '"Clocked"'
    size: baud
    srate: baud
    tr_delay: '100e-3'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame"'
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Audio"'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RF"'
    type: complex
    wintype: window.WIN_HANN
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: intx
    value: '41000'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: txbits
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: txbits
  states: {}

connections:
- [analog_agc2_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_agc2_xx_0, '0', qtgui_time_sink_x_1, '0']
- [analog_quadrature_demod_cf_0, '0', analog_agc2_xx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_repeat_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_message_strobe_0, strobe, digital_hdlc_framer_pb_0, in]
- [blocks_repeat_0, '0', blocks_vco_f_0, '0']
- [blocks_repeat_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_vco_f_0, '0', hilbert_fc_0, '0']
- [blocks_vco_f_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_hdlc_deframer_bp_1, '0']
- [digital_hdlc_deframer_bp_1, out, pad_sink_1, in]
- [digital_hdlc_framer_pb_0, '0', blocks_char_to_float_0, '0']
- [digital_hdlc_framer_pb_0, '0', virtual_sink_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_3, '0']
- [fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [freq_xlating_fft_filter_ccc_0, '0', analog_quadrature_demod_cf_0, '0']
- [hilbert_fc_0, '0', fir_filter_xxx_0, '0']
- [hilbert_fc_0, '0', pad_sink_0, '0']
- [pad_source_0, out, digital_hdlc_framer_pb_0, in]
- [pad_source_1, '0', freq_xlating_fft_filter_ccc_0, '0']
- [virtual_source_0, '0', blocks_char_to_float_0_0, '0']

metadata:
  file_format: 1

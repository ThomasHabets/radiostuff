options:
  parameters:
    author: thompa
    generate_options: qt_gui
    id: modem_test
    output_language: python
    title: Modem under test
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: modem_fsk_0
  id: modem_fsk
  parameters: {}
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '53001'
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '53002'
    type: UDP_CLIENT
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: air
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: air
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [modem_fsk_0, '0', blocks_multiply_const_vxx_0, '0']
- [modem_fsk_0, outpdu, blocks_message_debug_0, print]
- [modem_fsk_0, outpdu, network_socket_pdu_1, pdus]
- [network_socket_pdu_0, pdus, modem_fsk_0, inpdu]
- [virtual_source_0, '0', modem_fsk_0, '0']

metadata:
  file_format: 1

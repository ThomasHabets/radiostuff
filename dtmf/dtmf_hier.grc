options:
  parameters:
    author: thomas@habets.se
    generate_options: hb
    id: dtmf_hier
    output_language: python
    title: DTMF decoder hier block
  states: {}

blocks:
- name: audio_rate
  id: parameter
  parameters:
    type: intx
    value: '48000'
  states: {}
- name: blocks_and_xx_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0_0_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0_0_0_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0_0_0_0_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0_1_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0_1_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0_1_0_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_1_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_1_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_0_1_0_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_1_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_1_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_1_0_0_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.6'
    init: '0'
    low: '0.4'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.6'
    init: '0'
    low: '0.4'
  states: {}
- name: blocks_threshold_ff_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.6'
    init: '0'
    low: '0.4'
  states: {}
- name: blocks_threshold_ff_0_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.6'
    init: '0'
    low: '0.4'
  states: {}
- name: blocks_threshold_ff_0_0_1
  id: blocks_threshold_ff
  parameters:
    high: '0.6'
    init: '0'
    low: '0.4'
  states: {}
- name: blocks_threshold_ff_0_1
  id: blocks_threshold_ff
  parameters:
    high: '0.6'
    init: '0'
    low: '0.4'
  states: {}
- name: blocks_threshold_ff_0_1_0
  id: blocks_threshold_ff
  parameters:
    high: '0.6'
    init: '0'
    low: '0.4'
  states: {}
- name: blocks_threshold_ff_0_2
  id: blocks_threshold_ff
  parameters:
    high: '0.6'
    init: '0'
    low: '0.4'
  states: {}
- name: filter_length
  id: parameter
  parameters:
    type: intx
    value: '1000'
  states: {}
- name: goertzel_fc_0
  id: goertzel_fc
  parameters:
    freq: '1209'
    len: filter_length
    rate: audio_rate
  states: {}
- name: goertzel_fc_0_0
  id: goertzel_fc
  parameters:
    freq: '1336'
    len: filter_length
    rate: audio_rate
  states: {}
- name: goertzel_fc_0_0_0
  id: goertzel_fc
  parameters:
    freq: '1477'
    len: filter_length
    rate: audio_rate
  states: {}
- name: goertzel_fc_0_0_0_0
  id: goertzel_fc
  parameters:
    freq: '1633'
    len: filter_length
    rate: audio_rate
  states: {}
- name: goertzel_fc_0_0_0_0_0
  id: goertzel_fc
  parameters:
    freq: '697'
    len: filter_length
    rate: audio_rate
  states: {}
- name: goertzel_fc_0_0_0_1
  id: goertzel_fc
  parameters:
    freq: '770'
    len: filter_length
    rate: audio_rate
  states: {}
- name: goertzel_fc_0_0_1
  id: goertzel_fc
  parameters:
    freq: '852'
    len: filter_length
    rate: audio_rate
  states: {}
- name: goertzel_fc_0_1
  id: goertzel_fc
  parameters:
    freq: '941'
    len: filter_length
    rate: audio_rate
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    num_streams: '16'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: low_freqs
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: low_freqs
  states: {}

connections:
- [blocks_and_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_and_xx_0_0, '0', blocks_char_to_float_0_1_0_0, '0']
- [blocks_and_xx_0_0_0, '0', blocks_char_to_float_0_1, '0']
- [blocks_and_xx_0_0_0_0, '0', blocks_char_to_float_0_1_0, '0']
- [blocks_and_xx_0_0_0_0_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_1_0, '0']
- [blocks_and_xx_0_0_0_0_0_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_and_xx_0_0_0_0_0_0_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_1_0, '0']
- [blocks_and_xx_0_0_0_1_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_1, '0']
- [blocks_and_xx_0_0_0_1_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_and_xx_0_0_0_1_0_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_1, '0']
- [blocks_and_xx_0_0_1_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_1_0_0, '0']
- [blocks_and_xx_0_0_1_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_and_xx_0_0_1_0_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_1_0_0, '0']
- [blocks_and_xx_0_1_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_and_xx_0_1_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_and_xx_0_1_0_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_char_to_float_0, '0', pad_sink_0, '0']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0, '0', pad_sink_0, '12']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0, '0', pad_sink_0, '1']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0, '0', pad_sink_0, '2']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0_0, '0', pad_sink_0, '5']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0, '0', pad_sink_0, '8']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0, '0', pad_sink_0, '11']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_1, '0', pad_sink_0, '4']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_1_0, '0', pad_sink_0, '7']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_0_1_0_0, '0', pad_sink_0, '9']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_1, '0', pad_sink_0, '13']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_1_0, '0', pad_sink_0, '14']
- [blocks_char_to_float_0_0_0_0_0_0_0_0_0_0_0_1_0_0, '0', pad_sink_0, '15']
- [blocks_char_to_float_0_1, '0', pad_sink_0, '3']
- [blocks_char_to_float_0_1_0, '0', pad_sink_0, '6']
- [blocks_char_to_float_0_1_0_0, '0', pad_sink_0, '10']
- [blocks_complex_to_mag_0, '0', blocks_threshold_ff_0_0_0_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_threshold_ff_0_2, '0']
- [blocks_complex_to_mag_0_0_0, '0', blocks_threshold_ff_0_1_0, '0']
- [blocks_complex_to_mag_0_0_0_0, '0', blocks_threshold_ff_0_0_1, '0']
- [blocks_complex_to_mag_0_0_0_0_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_complex_to_mag_0_0_0_1, '0', blocks_threshold_ff_0_1, '0']
- [blocks_complex_to_mag_0_0_1, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_0_1, '0', blocks_threshold_ff_0_0_0, '0']
- [blocks_float_to_char_0, '0', blocks_and_xx_0, '1']
- [blocks_float_to_char_0, '0', blocks_and_xx_0_0, '1']
- [blocks_float_to_char_0, '0', blocks_and_xx_0_0_0, '1']
- [blocks_float_to_char_0, '0', blocks_and_xx_0_0_0_0, '1']
- [blocks_float_to_char_0_0, '0', blocks_and_xx_0_0_0_0_0_0_0_0_0, '1']
- [blocks_float_to_char_0_0, '0', blocks_and_xx_0_0_0_1_0_0_0_0, '1']
- [blocks_float_to_char_0_0, '0', blocks_and_xx_0_0_1_0_0_0_0, '1']
- [blocks_float_to_char_0_0, '0', blocks_and_xx_0_1_0_0_0_0, '1']
- [blocks_float_to_char_0_0_0, '0', blocks_and_xx_0_0_0_0_0_0_0, '1']
- [blocks_float_to_char_0_0_0, '0', blocks_and_xx_0_0_0_1_0_0, '1']
- [blocks_float_to_char_0_0_0, '0', blocks_and_xx_0_0_1_0_0, '1']
- [blocks_float_to_char_0_0_0, '0', blocks_and_xx_0_1_0_0, '1']
- [blocks_float_to_char_0_0_0_0, '0', blocks_and_xx_0_0_0_0_0_0_0_0, '1']
- [blocks_float_to_char_0_0_0_0, '0', blocks_and_xx_0_0_0_1_0_0_0, '1']
- [blocks_float_to_char_0_0_0_0, '0', blocks_and_xx_0_0_1_0_0_0, '1']
- [blocks_float_to_char_0_0_0_0, '0', blocks_and_xx_0_1_0_0_0, '1']
- [blocks_float_to_char_0_0_0_0_0, '0', blocks_and_xx_0_0_0, '0']
- [blocks_float_to_char_0_0_0_0_0, '0', blocks_and_xx_0_0_0_1_0_0, '0']
- [blocks_float_to_char_0_0_0_0_0, '0', blocks_and_xx_0_0_0_1_0_0_0, '0']
- [blocks_float_to_char_0_0_0_0_0, '0', blocks_and_xx_0_0_0_1_0_0_0_0, '0']
- [blocks_float_to_char_0_0_0_1, '0', blocks_and_xx_0_0_0_0, '0']
- [blocks_float_to_char_0_0_0_1, '0', blocks_and_xx_0_0_0_0_0_0_0, '0']
- [blocks_float_to_char_0_0_0_1, '0', blocks_and_xx_0_0_0_0_0_0_0_0, '0']
- [blocks_float_to_char_0_0_0_1, '0', blocks_and_xx_0_0_0_0_0_0_0_0_0, '0']
- [blocks_float_to_char_0_0_1, '0', blocks_and_xx_0, '0']
- [blocks_float_to_char_0_0_1, '0', blocks_and_xx_0_1_0_0, '0']
- [blocks_float_to_char_0_0_1, '0', blocks_and_xx_0_1_0_0_0, '0']
- [blocks_float_to_char_0_0_1, '0', blocks_and_xx_0_1_0_0_0_0, '0']
- [blocks_float_to_char_0_1, '0', blocks_and_xx_0_0, '0']
- [blocks_float_to_char_0_1, '0', blocks_and_xx_0_0_1_0_0, '0']
- [blocks_float_to_char_0_1, '0', blocks_and_xx_0_0_1_0_0_0, '0']
- [blocks_float_to_char_0_1, '0', blocks_and_xx_0_0_1_0_0_0_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_char_0_0_1, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_char_0_0_0_0_0, '0']
- [blocks_threshold_ff_0_0_0, '0', blocks_float_to_char_0_1, '0']
- [blocks_threshold_ff_0_0_0_0, '0', blocks_float_to_char_0, '0']
- [blocks_threshold_ff_0_0_1, '0', blocks_float_to_char_0_0_0_0, '0']
- [blocks_threshold_ff_0_1, '0', blocks_float_to_char_0_0_0_1, '0']
- [blocks_threshold_ff_0_1_0, '0', blocks_float_to_char_0_0_0, '0']
- [blocks_threshold_ff_0_2, '0', blocks_float_to_char_0_0, '0']
- [goertzel_fc_0, '0', blocks_complex_to_mag_0, '0']
- [goertzel_fc_0_0, '0', blocks_complex_to_mag_0_0_0, '0']
- [goertzel_fc_0_0_0, '0', blocks_complex_to_mag_0_0_0_0, '0']
- [goertzel_fc_0_0_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [goertzel_fc_0_0_0_0_0, '0', blocks_complex_to_mag_0_0_1, '0']
- [goertzel_fc_0_0_0_1, '0', blocks_complex_to_mag_0_0_0_0_0, '0']
- [goertzel_fc_0_0_1, '0', blocks_complex_to_mag_0_0_0_1, '0']
- [goertzel_fc_0_1, '0', blocks_complex_to_mag_0_1, '0']
- [pad_source_0, '0', goertzel_fc_0, '0']
- [pad_source_0, '0', goertzel_fc_0_0, '0']
- [pad_source_0, '0', goertzel_fc_0_0_0, '0']
- [pad_source_0, '0', goertzel_fc_0_0_0_0, '0']
- [pad_source_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', goertzel_fc_0_0_0_0_0, '0']
- [virtual_source_0, '0', goertzel_fc_0_0_0_1, '0']
- [virtual_source_0, '0', goertzel_fc_0_0_1, '0']
- [virtual_source_0, '0', goertzel_fc_0_1, '0']

metadata:
  file_format: 1

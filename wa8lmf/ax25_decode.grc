options:
  parameters:
    author: Thomas Habets <thomas@habets.se>
    generate_options: qt_gui
    id: test_ax25_decode
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: ofs
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '-1700*2*3.141592653589793/samp_rate'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/baud
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: byte
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: ofs
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-sps'
    type: float
  states: {}
- name: blocks_add_const_vxx_1_0
  id: blocks_add_const_vxx
  parameters:
    const: '-sps'
    type: float
  states: {}
- name: blocks_add_const_vxx_1_1
  id: blocks_add_const_vxx
  parameters:
    const: '-sps'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: cd_tracks_01.wav
    repeat: 'False'
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    num_inputs: '3'
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '500'
    min: '22'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 10*3.14/100+0*0.045
    max_dev: '0.02'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '255'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"Quad demod"'
    size: int(samp_rate*sps)
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Signal
    label2: Error
    label3: T inst
    label4: T avg
    name: '"Clock"'
    nconnections: '4'
    size: samp_rate
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: clocked
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: fsk
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: clocked
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: fsk
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_xor_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', virtual_sink_1, '0']
- [blocks_add_const_vxx_1, '0', qtgui_time_sink_x_1, '1']
- [blocks_add_const_vxx_1_0, '0', qtgui_time_sink_x_1, '2']
- [blocks_add_const_vxx_1_1, '0', qtgui_time_sink_x_1, '3']
- [blocks_delay_0, '0', blocks_xor_xx_0, '2']
- [blocks_wavfile_source_0, '0', hilbert_fc_0, '0']
- [blocks_xor_xx_0, '0', digital_hdlc_deframer_bp_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_delay_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_xor_xx_0, '1']
- [digital_hdlc_deframer_bp_0, out, blocks_message_debug_0, print]
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_1, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_0, '0']
- [digital_symbol_sync_xx_0, '1', blocks_add_const_vxx_1, '0']
- [digital_symbol_sync_xx_0, '2', blocks_add_const_vxx_1_0, '0']
- [digital_symbol_sync_xx_0, '3', blocks_add_const_vxx_1_1, '0']
- [hilbert_fc_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0, '0', digital_binary_slicer_fb_0, '0']
- [virtual_source_1, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0

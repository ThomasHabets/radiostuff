options:
  parameters:
    author: thompa
    generate_options: qt_gui
    id: modem_test
    output_language: python
    title: Modem under test
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: burst_bandwidth
  id: variable_qtgui_entry
  parameters:
    gui_hint: 'tabs@1: 0,1'
    type: real
    value: 2*baud
  states: {}
- name: burstthresh
  id: variable_qtgui_entry
  parameters:
    gui_hint: 'tabs@1: 0,0'
    type: real
    value: '0.250'
  states: {}
- name: igain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: ofs
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: ogain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: rxfreq
  id: variable
  parameters:
    value: '433200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: txfreq
  id: variable
  parameters:
    value: '433200000'
  states: {}
- name: ax25_hier_rx_ng_0
  id: ax25_hier_rx_ng
  parameters:
    audio_rate: '12000'
    bps: '1200'
    max_packet: '500'
    min_packet: '4'
    samp_rate: samp_rate
  states: {state: disabled}
- name: ax25_hier_tx_0
  id: ax25_hier_tx
  parameters:
    audio_rate: '12000'
    bps: '1200'
    parameter_3: '0'
    samp_rate: '50000'
  states: {state: disabled}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: frame
    true_value: 'True'
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: 1/burstthresh
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: ofs
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate, 30000, 1000)
  states: {}
- name: freq_xlating_fft_filter_ccc_1
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '-ofs'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1,samp_rate,ofs-12500,ofs+12500,1000)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: burst_bandwidth
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: burst_bandwidth/5
    win: window.WIN_HAMMING
  states: {}
- name: modem_ax1200_0
  id: modem_ax1200
  parameters:
    audio_rate: '12000'
    baud: baud
    max_packet: '500'
    min_packet: '32'
    samp_rate: samp_rate
  states: {}
- name: modem_fsk_0
  id: modem_fsk
  parameters:
    baud: '1200'
    gui_hint: tabs@2
    samp_rate: '200000'
  states: {state: disabled}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '53001'
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '53002'
    type: UDP_CLIENT
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: txfreq-ofs
    gain0: ogain*60
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: rxfreq-ofs
    gain0: 60*igain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 'tabs@1: 1,0,1,2'
    name: '"Magnitude"'
    size: samp_rate
    srate: samp_rate
    tr_delay: '10e-3'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0
    name: '"Received"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"To tx"'
    type: complex
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: txfreq-ofs
    gain: (73-17)*ogain+17
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: rxfreq-ofs
    gain: 61*igain-1
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Raw
    label1: Burst
    label2: Modem
    num_tabs: '3'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: txfreq-ofs
    gain0: ogain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: rxfreq-ofs
    gain0: igain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [ax25_hier_rx_ng_0, out, blocks_message_debug_0, print]
- [ax25_hier_rx_ng_0, out, network_socket_pdu_1, pdus]
- [ax25_hier_tx_0, '0', freq_xlating_fft_filter_ccc_1, '0']
- [blocks_burst_tagger_0, '0', ax25_hier_rx_ng_0, '0']
- [blocks_burst_tagger_0, '0', modem_ax1200_0, '0']
- [blocks_burst_tagger_0, '0', modem_fsk_0, '0']
- [blocks_complex_to_mag_0, '0', low_pass_filter_0, '0']
- [blocks_float_to_short_0, '0', blocks_burst_tagger_0, '1']
- [freq_xlating_fft_filter_ccc_0, '0', blocks_burst_tagger_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fft_filter_ccc_1, '0', osmosdr_sink_0, '0']
- [freq_xlating_fft_filter_ccc_1, '0', qtgui_waterfall_sink_x_1, '0']
- [freq_xlating_fft_filter_ccc_1, '0', soapy_bladerf_sink_0, '0']
- [freq_xlating_fft_filter_ccc_1, '0', uhd_usrp_sink_0, '0']
- [low_pass_filter_0, '0', blocks_float_to_short_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [modem_ax1200_0, '0', freq_xlating_fft_filter_ccc_1, '0']
- [modem_ax1200_0, pduout, blocks_message_debug_0, print]
- [modem_ax1200_0, pduout, network_socket_pdu_1, pdus]
- [modem_fsk_0, '0', freq_xlating_fft_filter_ccc_1, '0']
- [modem_fsk_0, outpdu, blocks_message_debug_0, print]
- [modem_fsk_0, outpdu, network_socket_pdu_1, pdus]
- [network_socket_pdu_0, pdus, ax25_hier_tx_0, in]
- [network_socket_pdu_0, pdus, modem_ax1200_0, pduin]
- [network_socket_pdu_0, pdus, modem_fsk_0, inpdu]
- [osmosdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [soapy_bladerf_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']

metadata:
  file_format: 1

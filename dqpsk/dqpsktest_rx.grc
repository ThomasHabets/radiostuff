options:
  parameters:
    author: thomas@habets.se
    copyright: thomas@habets.se
    generate_options: qt_gui
    id: dqpsktest_rx
    output_language: python
    title: DQPSK RX test
  states: {}

blocks:
- name: deci
  id: variable
  parameters:
    value: '10'
  states: {}
- name: igain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: loop_bandwidth
  id: variable_qtgui_entry
  parameters:
    gui_hint: 'tabs@1: 1,1'
    type: real
    value: 3.14e-3/deci
  states: {}
- name: qpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '32'
  states: {}
- name: tune_offset
  id: variable
  parameters:
    value: '-100e3'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '5'
    max_gain: '65536'
    rate: '1e-4'
    reference: '0.8'
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_2_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '23002'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {state: disabled}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1/8.0
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '0101010110101010'
    tagname: packet_len
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: loop_bandwidth
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_dqpsk().base()
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-tune_offset'
    decim: '1'
    samp_rate: samp_rate*deci
    taps: firdes.low_pass(1,samp_rate*10,20e3,2e3)
    type: ccc
  states: {}
- name: note_0
  id: note
  parameters:
    note: Aether
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'tabs@1: 0,2'
    name: '"Clock synced (clean)"'
    size: '1024'
    tr_tag: '"tx_sob"'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'tabs@1: 0,0'
    name: '"Over the air (rotating chaos)"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'tabs@1: 0,1,1,1'
    name: '"Frequency locked (stable chaos)"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@0
    size: '1024'
    srate: samp_rate*deci
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tabs@2: 2,0,1,3'
    marker1: '0'
    name: '"Output bytes"'
    size: '50'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '256'
  states: {}
- name: qtgui_time_sink_x_0_1_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: 'tabs@2: 1,0,1,3'
    marker1: '0'
    name: '"Output diff bytes"'
    size: '32'
    srate: samp_rate
    tr_delay: '0.1e-3'
    tr_level: '0.1'
    tr_tag: '"tx_sob"'
    type: float
    ymax: '4'
  states: {}
- name: qtgui_time_sink_x_0_1_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 'tabs@2: 0,0,1,3'
    label1: Pre diff
    label2: Post diff
    marker1: '0'
    marker2: '2'
    name: '"Differ in QPSK space"'
    nconnections: '2'
    size: '32'
    srate: samp_rate
    tr_delay: '0.1e-3'
    tr_level: '0.1'
    tr_tag: '"tx_sob"'
    type: float
    width2: '2'
    ymax: '4'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tabs@1: 2,0'
    name: '"Frequency offset"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tabs@1: 2,1'
    name: '"Phase offset"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tabs@1: 2,2'
    name: '"Error"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate*deci
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: deci
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: RF
    label1: Frequency locked
    label2: Bytes
    num_tabs: '3'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 2320000000-tune_offset
    dc_offs_enb0: '""'
    gain0: igain
    iq_imbal_enb0: '""'
    norm_gain0: 'True'
    samp_rate: samp_rate*deci
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: from_air
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: from_air
  states: {}

connections:
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_agc_xx_0, '0', virtual_sink_2, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_1_1_0_0_0, '0']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_0_1_1_0_0_0, '1']
- [blocks_char_to_float_2, '0', qtgui_time_sink_x_0_1_1, '0']
- [blocks_char_to_float_2_0_0, '0', qtgui_time_sink_x_0_1_1_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_char_to_float_2_0_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', digital_crc32_bb_1, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_socket_pdu_0, pdus]
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_1_0, '0']
- [digital_costas_loop_cc_0, '0', rational_resampler_xxx_1, '0']
- [digital_costas_loop_cc_0, '1', qtgui_time_sink_x_1, '0']
- [digital_costas_loop_cc_0, '2', qtgui_time_sink_x_1_0, '0']
- [digital_costas_loop_cc_0, '3', qtgui_time_sink_x_1_0_0, '0']
- [digital_crc32_bb_1, '0', blocks_char_to_float_2, '0']
- [digital_crc32_bb_1, '0', blocks_tagged_stream_to_pdu_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_char_to_float_0_1, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', digital_symbol_sync_xx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_1, '0', digital_costas_loop_cc_0, '0']
- [virtual_source_1, '0', qtgui_const_sink_x_0_1, '0']

metadata:
  file_format: 1

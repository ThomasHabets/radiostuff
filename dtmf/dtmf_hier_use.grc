options:
  parameters:
    author: thomas@habets.se
    generate_options: qt_gui
    id: dtmf_hier_use
    output_language: python
    title: DTMF decoder
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: deci1
  id: variable
  parameters:
    value: '10'
  states: {}
- name: dtmfgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '5'
  states: {}
- name: freq_m
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0
    type: real
    value: '435'
  states: {}
- name: igain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sql_level
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '0'
    value: '-60'
  states: {}
- name: twidth
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {state: disabled}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(samp_rate/deci1)
    max_dev: 5e3
    quad_rate: int(samp_rate/deci1)
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sql_level
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: dtmfgain
    type: float
  states: {}
- name: dtmf_hier_0
  id: dtmf_hier
  parameters:
    audio_rate: '48000'
    filter_length: '1000'
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '0'
    decim: deci1
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,cutoff,twidth)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,1,2
    name: '"Digits"'
    nconnections: '10'
    size: '128'
    srate: audio_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,2,1,2
    name: '"Special"'
    nconnections: '6'
    size: '128'
    srate: audio_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/deci1)
    interp: audio_rate
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq_m*1e6
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: igain
    iq_imbal_enb0: '""'
    norm_gain0: 'True'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_1, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', dtmf_hier_0, '0']
- [dtmf_hier_0, '0', qtgui_time_sink_x_0, '0']
- [dtmf_hier_0, '1', qtgui_time_sink_x_0, '1']
- [dtmf_hier_0, '10', qtgui_time_sink_x_0_0, '0']
- [dtmf_hier_0, '11', qtgui_time_sink_x_0_0, '1']
- [dtmf_hier_0, '12', qtgui_time_sink_x_0_0, '2']
- [dtmf_hier_0, '13', qtgui_time_sink_x_0_0, '3']
- [dtmf_hier_0, '14', qtgui_time_sink_x_0_0, '4']
- [dtmf_hier_0, '15', qtgui_time_sink_x_0_0, '5']
- [dtmf_hier_0, '2', qtgui_time_sink_x_0, '2']
- [dtmf_hier_0, '3', qtgui_time_sink_x_0, '3']
- [dtmf_hier_0, '4', qtgui_time_sink_x_0, '4']
- [dtmf_hier_0, '5', qtgui_time_sink_x_0, '5']
- [dtmf_hier_0, '6', qtgui_time_sink_x_0, '6']
- [dtmf_hier_0, '7', qtgui_time_sink_x_0, '7']
- [dtmf_hier_0, '8', qtgui_time_sink_x_0, '8']
- [dtmf_hier_0, '9', qtgui_time_sink_x_0, '9']
- [freq_xlating_fft_filter_ccc_0, '0', analog_simple_squelch_cc_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1

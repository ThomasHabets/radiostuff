options:
  parameters:
    author: thomas@habets.se
    generate_options: qt_gui
    id: ssb_rx
    output_language: python
    title: SSB RX
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1
    type: int
    value: '433800000'
  states: {}
- name: igain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: sideband
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,2,1
    label0: USB
    label1: LSB
    num_opts: '2'
    option1: '0'
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 3000*sideband + -300 * (1-sideband)
    low_cutoff_freq: 300*sideband + -3000*(1-sideband)
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    gui_hint: 2,0,6,2
    name: '"RF spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 2,2,6,2
    name: '"Audio"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: audio_rate
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: igain
    iq_imbal_enb0: '""'
    norm_gain0: 'True'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [band_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_complex_to_float_0, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_float_0, '1', blocks_add_xx_0, '1']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']
- [uhd_usrp_source_0, '0', band_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1

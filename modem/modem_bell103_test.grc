options:
  parameters:
    author: thompa
    generate_options: qt_gui
    id: modem_bell103_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: test_message
  id: variable
  parameters:
    value: '"The quick brown fox jumped over the lazy dog 1234567890"'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(test_message), [ord(x) for x in test_message]))
    period: '100'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: modem_bell103_0
  id: modem_bell103
  parameters:
    samp_rate: samp_rate
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [blocks_message_strobe_0, strobe, modem_bell103_0, pduin]
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [modem_bell103_0, '0', blocks_multiply_const_vxx_0, '0']
- [modem_bell103_0, pduout, blocks_message_debug_0, print]
- [virtual_source_0, '0', modem_bell103_0, '0']

metadata:
  file_format: 1

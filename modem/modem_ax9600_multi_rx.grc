options:
  parameters:
    author: thomas@habets.se
    generate_options: qt_gui
    id: modem_ax9600_multi_rx
    output_language: python
    title: AX.25 multi receiver
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: cutoff
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,2
    type: int
    value: '12400'
  states: {}
- name: deci
  id: variable
  parameters:
    value: '10'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,0
    type: int
    value: '144500000'
  states: {}
- name: igain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,1
    type: real
    value: '0.3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: twidth
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,3
    type: int
    value: '100'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '0'
    decim: deci
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,49700,100)
  states: {}
- name: modem_ax9600_grsat_hier_rx_0
  id: modem_ax9600_grsat_hier_rx
  parameters:
    baud: baud
    samp_rate: samp_rate//deci//4
  states: {}
- name: modem_ax9600_grsat_hier_rx_0_0
  id: modem_ax9600_grsat_hier_rx
  parameters:
    baud: baud
    samp_rate: samp_rate//deci//4
  states: {}
- name: modem_ax9600_grsat_hier_rx_0_0_0
  id: modem_ax9600_grsat_hier_rx
  parameters:
    baud: baud
    samp_rate: samp_rate//deci//4
  states: {}
- name: modem_ax9600_grsat_hier_rx_0_1
  id: modem_ax9600_grsat_hier_rx
  parameters:
    baud: baud
    samp_rate: samp_rate//deci//4
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52009'
    type: UDP_CLIENT
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[0,1,3,2]'
    nchans: '4'
    osr: '1.0'
    taps: firdes.low_pass(1,samp_rate//deci,cutoff,twidth)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 2,0,1,1
    name: '"Channel 0"'
    size: samp_rate//deci//4
    srate: samp_rate//deci//4
    tr_delay: '0.1'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 2,1,1,1
    name: '"Channel 1"'
    size: samp_rate//deci//4
    srate: samp_rate//deci//4
    tr_delay: '0.1'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 2,2,1,1
    name: '"Channel 2"'
    size: samp_rate//deci//4
    srate: samp_rate//deci//4
    tr_delay: '0.1'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate//deci
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,3
    name: '"100kHz"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate//deci//4
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1
    name: '"Channel 1"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate//deci//4
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0
    name: '"Channel 0"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate//deci//4
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,2
    name: '"Channel 2"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate//deci//4
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,3
    name: '"Channel 3"'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1024000'
    interp: samp_rate
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    gain0: igain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: air
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: air
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', pfb_channelizer_ccf_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [modem_ax9600_grsat_hier_rx_0, out, blocks_message_debug_0, print]
- [modem_ax9600_grsat_hier_rx_0_0, out, blocks_message_debug_0, print]
- [modem_ax9600_grsat_hier_rx_0_0_0, out, blocks_message_debug_0, print]
- [modem_ax9600_grsat_hier_rx_0_1, out, blocks_message_debug_0, print]
- [modem_ax9600_grsat_hier_rx_0_1, out, network_socket_pdu_0, pdus]
- [pfb_channelizer_ccf_0, '0', modem_ax9600_grsat_hier_rx_0, '0']
- [pfb_channelizer_ccf_0, '0', qtgui_time_sink_x_0, '0']
- [pfb_channelizer_ccf_0, '0', qtgui_waterfall_sink_x_1_0, '0']
- [pfb_channelizer_ccf_0, '1', modem_ax9600_grsat_hier_rx_0_0, '0']
- [pfb_channelizer_ccf_0, '1', qtgui_time_sink_x_0_0, '0']
- [pfb_channelizer_ccf_0, '1', qtgui_waterfall_sink_x_1, '0']
- [pfb_channelizer_ccf_0, '2', modem_ax9600_grsat_hier_rx_0_1, '0']
- [pfb_channelizer_ccf_0, '2', qtgui_time_sink_x_0_0_0, '0']
- [pfb_channelizer_ccf_0, '2', qtgui_waterfall_sink_x_1_1, '0']
- [pfb_channelizer_ccf_0, '3', modem_ax9600_grsat_hier_rx_0_0_0, '0']
- [pfb_channelizer_ccf_0, '3', qtgui_waterfall_sink_x_1_1_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [virtual_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0

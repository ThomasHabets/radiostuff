options:
  parameters:
    author: Thomas Habets <thomas@habets.se>
    generate_options: qt_gui
    id: ax25_tranceiver
    output_language: python
    title: AX.25 Tranceiver
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: deci
  id: variable
  parameters:
    value: '4'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '144775000'
  states: {}
- name: igain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: offset
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: ogain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: ax25_hier_rx_ng_0
  id: ax25_hier_rx_ng
  parameters:
    audio_rate: '12000'
    bps: '1200'
    samp_rate: '50000'
  states: {}
- name: ax25_hier_tx_0
  id: ax25_hier_tx
  parameters:
    audio_rate: '12000'
    bps: '1200'
    parameter_3: '0'
    samp_rate: '50000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '-offset'
    decim: deci
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate, 20000, 1000)
  states: {}
- name: freq_xlating_fft_filter_ccc_1
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '-offset'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, offset-12500, offset+12500, 500)
  states: {}
- name: habets39_pdu_file_writer_0
  id: habets39_pdu_file_writer
  parameters:
    output_dir: captured
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50000'
    interp: samp_rate
    type: ccc
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    center_freq: freq-offset
    gain: ogain*(64+12)-12
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    center_freq: freq-offset
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq-offset
    dev_args: '""'
    gain0: ogain
    gain_type0: normalized
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq-offset
    dev_args: '""'
    gain0: igain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: air_rx
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: air_rx
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: air_tx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: air_rx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: air_tx
  states: {state: disabled}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: air_tx
  states: {}

connections:
- [ax25_hier_rx_ng_0, out, blocks_message_debug_0, print_pdu]
- [ax25_hier_rx_ng_0, out, blocks_socket_pdu_0, pdus]
- [ax25_hier_rx_ng_0, out, habets39_pdu_file_writer_0, in]
- [ax25_hier_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_socket_pdu_0, pdus, ax25_hier_tx_0, in]
- [blocks_socket_pdu_0, pdus, blocks_message_debug_0_0, print_pdu]
- [freq_xlating_fft_filter_ccc_0, '0', ax25_hier_rx_ng_0, '0']
- [freq_xlating_fft_filter_ccc_1, '0', virtual_sink_1, '0']
- [rational_resampler_xxx_0, '0', freq_xlating_fft_filter_ccc_1, '0']
- [soapy_limesdr_source_0, '0', virtual_sink_0_0, '0']
- [uhd_usrp_source_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [virtual_source_1, '0', uhd_usrp_sink_0, '0']
- [virtual_source_1_0, '0', soapy_limesdr_sink_0, '0']

metadata:
  file_format: 1

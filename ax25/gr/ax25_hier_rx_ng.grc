options:
  parameters:
    author: Thomas Habets <thomas@habets.se>
    category: habets
    generate_options: hb_qt_gui
    id: ax25_hier_rx_ng
    output_language: python
    title: AX.25 RX ng
  states: {}

blocks:
- name: monitor_volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.01'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: byte
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: audio_rate
  id: parameter
  parameters:
    label: Audio rate
    type: intx
    value: '12000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: monitor_volume
    type: float
  states: {state: disabled}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    num_inputs: '3'
    type: byte
  states: {}
- name: bps
  id: parameter
  parameters:
    label: BPS
    type: intx
    value: '1200'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_corr_est_cc_1
  id: digital_corr_est_cc
  parameters:
    mark_delay: '0'
    sps: audio_rate/bps
    symbols: '[1,1,1,1,1,1,1,-1]*8'
    threshold: '0.1'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '01111110'
    tagname: flag
    threshold: '0'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '01111110011111100111111001111110'
    comment: Only used for graph trigger
    tagname: flag4
    threshold: '0'
    type: byte
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '500'
    min: '32'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: audio_rate/bps
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Tag2PDU
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio.gr import pmt


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Blah"""

          def __init__(self, start_tag='flag4', end_tag='flag'):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Tag2PDU',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[]
              )
              self._start_tag = start_tag
              self._end_tag = end_tag
              self._out = pmt.intern('out')
              self._active = False
              self.message_port_register_out(self._out)

          def work(self, input_items, output_items):
              """."""

              tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              nr = self.nitems_read(0)
              tagmap = {}
              for tag in tags:
                  key = pmt.to_python(tag.key)
                  ofs = tag.offset-nr
                  tagmap.setdefault(ofs, set()).add(key)

              for ind, sample in enumerate(input_items[0]):
                  st = self._start_tag in tagmap.get(ind, set())
                  et = self._end_tag in tagmap.get(ind, set())
                  if st:
                      self._active = True
                      self._data = []
                  if not self._active:
                      continue
                  self._data.append(sample)
                  if et and not st:
                      if len(self._data) > 24:
                          print("HABETS: got packet size %d bits"
                                % len(self._data))
                          print(self._data)
                          d = [int(x) for x in self._data]
                          pdu = pmt.cons(pmt.PMT_NIL,
                                         pmt.init_u8vector(len(d), d))
                          self.message_port_pub(self._out, pdu)
                      self._active = False
              self.consume(0, len(input_items[0]))
              return 0
    end_tag: '''flag'''
    start_tag: '''flag4'''
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nfrom gnuradio.gr import pmt\n\n\nclass blk(gr.basic_block):\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self):\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='AX.25 Unstuff',\n            in_sig=[],\n            out_sig=[]\n        )\n        self._in = pmt.intern('in')\n        self._out = pmt.intern('out')\n        self.message_port_register_in(self._in)\n        self.message_port_register_out(self._out)\n        self.set_msg_handler(self._in, self._handle)\n\n    def _handle(self, msg):\n        print(\"HABETS: got a message to unstuff\")\n        bits = [int(x) for x in pmt.to_python(pmt.cdr(msg))]\n        bits = self._unstuff(bits)\n        pdu = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(bits),bits))\n        self.message_port_pub(self._out, pdu)\n        \n    def _unstuff(self, bits):\n        out = []\n        n = 0\n        for b in bits:\n            assert b < 6\n            if b:\n                n += 1\n            else:\n                if n == 5:\n                    n = 0\n                    continue\n                n = 0\n            out.append(b)\n        return out\n\n\n"
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (2200+1200)/2
    decim: '1'
    samp_rate: audio_rate
    taps: firdes.low_pass(1,audio_rate, 1200,100)
    type: fcc
  states: {}
- name: habets39_hdlc_unstuff_0
  id: habets39_hdlc_unstuff
  parameters: {}
  states: {state: disabled}
- name: habets39_pdu_pack_0
  id: habets39_pdu_pack
  parameters:
    strict: 'False'
  states: {state: disabled}
- name: habets39_tag2pdu_0
  id: habets39_tag2pdu
  parameters:
    min_size: '24'
    tag_end: flag
    tag_start: flag4
  states: {state: disabled}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@0
    name: '"Air"'
    size: samp_rate
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@1
    name: '"Quadrature demod"'
    size: '1024'
    srate: audio_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@2
    size: '1024'
    srate: bps
    type: complex
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tabs@3
    marker1: '0'
    size: bps
    srate: bps
    tr_delay: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"flag4"'
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0
    name: '"Air"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: audio_rate
    taps: ''
    type: fff
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: intx
    value: '50000'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Air
    label1: Audio
    label2: Quad
    label3: Clocked
    label4: Bits
    num_tabs: '5'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: air
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: quad
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: clocked
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: bits
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: air
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: quad
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: clocked
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: bits
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_xor_xx_0, '2']
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_1, '0']
- [analog_quadrature_demod_cf_0, '0', virtual_sink_1, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_3, '0']
- [blocks_complex_to_float_1, '0', digital_binary_slicer_fb_0, '0']
- [blocks_delay_0, '0', blocks_xor_xx_0, '1']
- [blocks_float_to_complex_0, '0', digital_corr_est_cc_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_tag_gate_0, '0', virtual_sink_5, '0']
- [blocks_xor_xx_0, '0', blocks_tag_gate_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_delay_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_xor_xx_0, '0']
- [digital_corr_est_cc_1, '0', digital_symbol_sync_xx_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_char_to_float_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', epy_block_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', habets39_tag2pdu_0, '0']
- [digital_correlate_access_code_tag_xx_0_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_hdlc_deframer_bp_0, out, pad_sink_0, in]
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_2, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_2, '0']
- [epy_block_0, out, epy_block_2, in]
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [habets39_hdlc_unstuff_0, out, habets39_pdu_pack_0, in]
- [habets39_pdu_pack_0, out, pad_sink_0, in]
- [habets39_tag2pdu_0, pdus, epy_block_2, in]
- [habets39_tag2pdu_0, pdus, habets39_hdlc_unstuff_0, in]
- [pad_source_0, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_0, '0', analog_nbfm_rx_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_1, '0', blocks_float_to_complex_0, '0']
- [virtual_source_2, '0', blocks_complex_to_float_1, '0']
- [virtual_source_6, '0', digital_correlate_access_code_tag_xx_0_0, '0']
- [virtual_source_6, '0', digital_hdlc_deframer_bp_0, '0']

metadata:
  file_format: 1

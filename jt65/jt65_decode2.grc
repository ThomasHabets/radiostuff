<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>jt65_decode2</value></param>
<param><key>author</key><value>Thomas Habets &lt;thomas@habets.se&gt;</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>audio_rate</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>2067012</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>jt65.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>habets_jt65_decode</key>
<param><key>id</key><value>habets_jt65_decode_0</value></param>
<param><key>buckets_per_symbol</key><value>10</value></param>
<param><key>fft_size</key><value>8192</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sps</key><value>int(samp_rate*0.372)</value></param>
<param><key>symbol_offset</key><value>10.8</value></param>
</block>
<block>
<key>habets_tagged_stream_to_large_pdu_f</key>
<param><key>id</key><value>habets_tagged_stream_to_large_pdu_f_0</value></param>
<param><key>length_tag</key><value>packet_len</value></param>
</block>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>habets_tagged_stream_to_large_pdu_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>habets_jt65_decode_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>habets_tagged_stream_to_large_pdu_f_0</source_block_id><sink_block_id>habets_jt65_decode_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>

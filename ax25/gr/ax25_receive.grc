options:
  parameters:
    author: Thomas Habets
    generate_options: qt_gui
    id: ax25_receive
    output_language: python
    title: AX.25 receive
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: bps
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: deci
  id: variable
  parameters:
    value: '4'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '144775000'
  states: {state: disabled}
- name: igain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@0: 2,0'
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {state: disabled}
- name: igain_file
  id: variable_qtgui_entry
  parameters:
    gui_hint: 'tabs@0: 2,0'
    type: real
    value: '20'
  states: {}
- name: offset
  id: variable
  parameters:
    value: '50000'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: speedup
  id: variable
  parameters:
    value: '10'
  states: {}
- name: sql
  id: variable_qtgui_entry
  parameters:
    gui_hint: 'tabs@0: 2,1'
    type: real
    value: '-5'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: byte
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'False'
    ramp: '0'
    threshold: sql
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: temp_captured-50ksps.raw
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/thompa/scm/radiostuff/ax25/gr/aprs1200_50ksps.raw
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: transmitted-msg4-50ksps.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: igain_file
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"corr_est"'
    type: byte
  states: {}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"amp_est"'
    type: byte
  states: {}
- name: blocks_tag_gate_0_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"corr_start"'
    type: byte
  states: {}
- name: blocks_tag_gate_0_1_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"time_est"'
    type: byte
  states: {}
- name: blocks_tag_gate_0_1_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"phase_est"'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: int(speedup*samp_rate)
    type: complex
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    num_inputs: '3'
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_corr_est_cc_1
  id: digital_corr_est_cc
  parameters:
    mark_delay: '0'
    sps: audio_rate/bps
    symbols: '[0,0,0,0,0,0,0,1]*8'
    threshold: '0.1'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '01111110'
    tagname: flag
    threshold: '0'
    type: byte
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: audio_rate/bps
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: audio_rate/bps
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """AX25 decoder block

      This block takes an input stream with a burst starting with one tag
      and ending with another.

      It then takes those bits, NRZ unscrambles them, and decodes the bytes
      as LSB by bytes.
      """

      import numpy as np
      import time
      import tempfile
      from gnuradio import gr
      from gnuradio.gr import pmt

      debug = False

      class blk(gr.basic_block):
          """Blah"""

          def __init__(self, flag_tag="flag", burst_tag="squelch_sob"):
              """Init."""
              gr.sync_block.__init__(
                  self,
                  name='AX.25 decoder',
                  in_sig=[np.byte],
                  out_sig=[]
              )
              self._data = []
              # Ugly state machine:
              # 0 = waiting for burst tag
              # 1 = waiting for flag tag
              # 2 = got flag tag, accumulating data until end-of-packet flag
              self._state = 0
              self._flag_tag = flag_tag
              self._sob_tag = burst_tag
              self._pub = pmt.intern("pdus")
              self.message_port_register_out(self._pub)

          def work(self, input_items, output_items):
              """"""
              inp = input_items[0]

              # Prep tag map.
              tags = self.get_tags_in_window(0, 0, len(inp))
              tagmap = {}
              nr = self.nitems_read(0)
              for tag in tags:
                  key = pmt.to_python(tag.key)
                  ofs = tag.offset-nr
                  tagmap.setdefault(ofs, set()).add(key)
              if tagmap:
                  pass
                  #print(len(inp), tagmap)

              # Fast path: not accumulating.
              if not self._state and not tagmap:
                  self.consume(0, len(inp))
                  return 0

              for ind, sample in enumerate(inp):
                  if self._sob_tag in tagmap.get(ind, set()):
                      if debug:
                          print("AX.25 got sob: state -> 1")
                      self._state = 1
                  if self._state == 0:
                      continue

                  if self._flag_tag in tagmap.get(ind, set()):
                      if debug:
                          print("AX.25 got flag")
                      if self._state == 1:
                          if debug:
                              print("AX.25 got flag: state 1 -> 2")
                          self._data = []
                          self._state = 2
                      elif self._state == 2:
                          if len(self._data) < 24:
                              self._data = []
                          else:
                              if debug:
                                  print("AX.25 got flag after data: state 2 -> 0")
                              self._state = 0
                              bits = self._unstuff(self._data)
                              if debug:
                                  print(bits)
                              byt = self._pack(bits)
                              self.message_port_pub(self._pub, pmt.to_pmt(byt))
                              if debug:
                                  print("AX.25 packet arrived at %d. size %d -> %d" % (nr+ind, len(bits), len(byt)))
                                  with open('%s/ax25-%s.raw' % (tempfile.gettempdir(), str(time.time())), 'wb') as f:
                                      f.write(b''.join([x.to_bytes(1,byteorder='big') for x in byt]))
                              continue
                      
                  self._data.append(int(sample))
              self.consume(0, len(inp))
              return len(output_items)

          def _unstuff(self, bits):
              out = []
              n = 0
              for b in bits:
                  assert b < 6
                  if b:
                      n += 1
                  else:
                      if n == 5:
                          n = 0
                          continue
                      n = 0
                  out.append(b)
              return out

          def _pack(self, bits):
              byt = []
              while len(bits) > 8:
                  b, bits = bits[:8], bits[8:]
                  t = 1
                  by = 0
                  for sym in b:
                      if sym:
                          by += t
                      t *= 2
                  if by == 0x7E and len(byt):
                      break
                  if by != 0x7E:
                      byt.append(by)
              return byt
                  

      """
      B: 12345678  87654321
      --
      M: 10011010  01011001
      0: 01100000  00000110
      T: 10101000  00010101
      H: 10010000  00001001
      C: 10000110  01100001
       : 01000000  00000010
      A: 10000010  01000001
      """
    burst_tag: '''squelch_sob'''
    flag_tag: '''flag'''
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: offset
    decim: deci
    samp_rate: samp_rate*deci
    taps: firdes.low_pass(1, samp_rate*deci, 12500,1000)
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (2200+1200)/2
    decim: '1'
    samp_rate: audio_rate
    taps: firdes.low_pass(1,audio_rate, 1200,100)
    type: fcc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 'tabs@1: 0,0'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@2
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 'tabs@0: 0,0,1,2'
    name: '"Captured"'
    size: samp_rate
    srate: samp_rate
    tr_delay: '0.1'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 'tabs@0: 1,0,1,2'
    name: '"Squelched"'
    size: samp_rate
    srate: samp_rate
    tr_delay: '0.1'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tabs@2: 1,0'
    size: audio_rate
    srate: audio_rate
    tr_delay: '0.1'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 'tabs@1: 1,0'
    size: audio_rate
    srate: audio_rate
    tr_delay: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: float
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 'tabs@3: 0,0'
    name: '"Raw quad demod"'
    size: audio_rate
    srate: audio_rate
    tr_delay: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: float
  states: {}
- name: qtgui_time_sink_x_4
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 'tabs@3: 2,0'
    name: '"Correlation estimator"'
    nconnections: '2'
    size: audio_rate
    srate: audio_rate
    tr_delay: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_4_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 'tabs@3: 3,0'
    label1: Signal
    label2: Clock error
    marker1: '0'
    name: '"Clocked"'
    nconnections: '2'
    size: bps
    srate: bps
    tr_delay: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: float
  states: {}
- name: qtgui_time_sink_x_4_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 'tabs@3: 1,0'
    label1: Signal
    label2: Clock error
    marker1: '0'
    name: '"Clocked w/o correlation"'
    nconnections: '2'
    size: bps
    srate: bps
    tr_delay: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: float
  states: {}
- name: qtgui_time_sink_x_5
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tabs@4: 0,0'
    name: '"Bits"'
    size: bps*2
    srate: bps
    tr_delay: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"flag"'
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_5_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tabs@4: 1,0,3,1'
    name: '"Bits"'
    size: bps*2
    srate: bps
    tr_delay: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"flag"'
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: audio_rate
    taps: ''
    type: fff
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Raw
    label1: FM demod
    label2: Subcarrier
    label3: Quad demod
    label4: Bits
    num_tabs: '5'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate*deci
    center_freq0: freq-offset
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: igain
    iq_imbal_enb0: '""'
    norm_gain0: 'True'
    samp_rate: samp_rate*deci
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: squelched
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: audio
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: subcarrier
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: quad
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: clocked
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: bits
  states: {}
- name: virtual_sink_6
  id: virtual_sink
  parameters:
    stream_id: captured
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: captured
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: squelched
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: audio
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: subcarrier
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: quad
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: clocked
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: bits
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_xor_xx_0, '2']
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', virtual_sink_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_3, '0']
- [analog_quadrature_demod_cf_0, '0', virtual_sink_3, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_5, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_5_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_4_0, '0']
- [blocks_complex_to_float_0_0, '0', qtgui_time_sink_x_4_0_0, '0']
- [blocks_complex_to_float_1, '0', digital_binary_slicer_fb_0, '0']
- [blocks_delay_0, '0', blocks_xor_xx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0, '0', digital_corr_est_cc_1, '0']
- [blocks_float_to_complex_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_6, '0']
- [blocks_tag_gate_0, '0', blocks_tag_gate_0_0, '0']
- [blocks_tag_gate_0_0, '0', blocks_tag_gate_0_1_0, '0']
- [blocks_tag_gate_0_1, '0', blocks_tag_gate_0_1_0_0, '0']
- [blocks_tag_gate_0_1_0, '0', blocks_tag_gate_0_1, '0']
- [blocks_tag_gate_0_1_0_0, '0', virtual_sink_4, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_3, '0']
- [blocks_xor_xx_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_tag_gate_0, '0']
- [digital_corr_est_cc_1, '0', digital_symbol_sync_xx_0, '0']
- [digital_corr_est_cc_1, '0', qtgui_time_sink_x_4, '0']
- [digital_corr_est_cc_1, '1', qtgui_time_sink_x_4, '1']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_char_to_float_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', virtual_sink_5, '0']
- [digital_symbol_sync_xx_0, '0', blocks_complex_to_float_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_complex_to_float_1, '0']
- [digital_symbol_sync_xx_0, '1', qtgui_time_sink_x_4_0, '1']
- [digital_symbol_sync_xx_0_0, '0', blocks_complex_to_float_0_0, '0']
- [digital_symbol_sync_xx_0_0, '1', qtgui_time_sink_x_4_0_0, '1']
- [epy_block_0, pdus, blocks_message_debug_0, print]
- [freq_xlating_fft_filter_ccc_0, '0', blocks_file_sink_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', virtual_sink_6, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_2, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', virtual_sink_2, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_2, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_1, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [virtual_source_0, '0', analog_pwr_squelch_xx_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_1, '0', analog_nbfm_rx_0, '0']
- [virtual_source_2, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_3, '0', analog_quadrature_demod_cf_0, '0']
- [virtual_source_4, '0', blocks_float_to_complex_0, '0']
- [virtual_source_4, '0', qtgui_freq_sink_x_1, '0']
- [virtual_source_5, '0', blocks_delay_0, '0']
- [virtual_source_5, '0', blocks_xor_xx_0, '1']
- [virtual_source_6, '0', epy_block_0, '0']

metadata:
  file_format: 1
